# IAR project rx65n_secure_boot.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F565NE_DUAL R5F565NE_DUAL
  General.GenCodeModel: 0
  General.GenDataModel: 2
  General.StackSize: 0x0
  General.IStackSize: 0x1000
  General.HeapSize: 0x4000
  ICCRX.CCDefines: SECURE_BOOT=1; __RX
  ICCRX.CCDiagSuppress: Pe111,Pe226,Pa089,Pa182,Pa084,Pa093,Pa050,Pe009,Pe301,Pe167,Pe513,Pe177
  ICCRX.CCIncludePath2: src/smc_gen/r_bsp; src/smc_gen/r_config; src/smc_gen/r_flash_rx; src/smc_gen/r_flash_rx/src; src/smc_gen/r_flash_rx/src/flash_type_1; src/smc_gen/r_flash_rx/src/flash_type_2; src/smc_gen/r_flash_rx/src/flash_type_3; src/smc_gen/r_flash_rx/src/flash_type_4; src/smc_gen/r_flash_rx/src/targets; src/smc_gen/r_tfat_driver_rx; src/smc_gen/r_tfat_driver_rx/src; src/smc_gen/r_tfat_driver_rx/src/device/sdhi; src/smc_gen/r_tfat_driver_rx/src/device/usb; src/smc_gen/r_tfat_driver_rx/src/device/usb_mini; src/smc_gen/r_tfat_rx; src/smc_gen/r_tfat_rx/lib; src/smc_gen/r_usb_basic; src/smc_gen/r_usb_basic/src/driver/inc; src/smc_gen/r_usb_basic/src/hw/inc; src/smc_gen/r_usb_hmsc; src/smc_gen/r_usb_hmsc/src/inc; src/smc_gen/r_cmt_rx; src/smc_gen/r_cmt_rx/src; src/smc_gen/general; src/smc_gen/r_pincfg; src/src/sha1/include
  ICCRX.IccExtraOptions: --enum_is_int
  ICCRX.IccLang: 0
  OBJCOPY.OOCOutputFile: rx65n_secure_boot.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: rx65n_envision_secure_boot.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: rx65n_envision_secure_boot.ddf rx65n_envision_secure_boot.icf
    ../doc/: rx65n_envisionkit_demo_readme.txt
  group src/smc_gen/general
    src/smc_gen/general/: r_cg_bsc.h r_cg_cac.h r_cg_cmt.h r_cg_cmtw.h r_cg_crc.h r_cg_dmac.h r_cg_dmac_user.c r_cg_doc.h r_cg_dtc.h r_cg_elc.h r_cg_hardware_setup.c r_cg_icu.h r_cg_iwdt.h r_cg_lpc.h r_cg_lvd.h r_cg_macrodriver.h r_cg_mtu3.h r_cg_poe.h r_cg_port.h r_cg_ppg.h r_cg_r12da.h r_cg_riic.h r_cg_rspi.h r_cg_rtc.h r_cg_s12ad.h r_cg_sci.h r_cg_tmr.h r_cg_tpu.h r_cg_userdefine.h r_cg_wdt.h r_smc_cgc.c r_smc_cgc.h r_smc_cgc_user.c r_smc_entry.h r_smc_interrupt.c r_smc_interrupt.h
  group src/smc_gen/r_bsp
    src/smc_gen/r_bsp/: platform.h readme.txt
  group src/smc_gen/r_bsp/board/generic_rx65n
    src/smc_gen/r_bsp/board/generic_rx65n/: hwsetup.c hwsetup.h r_bsp.h r_bsp_config_reference.h r_bsp_interrupt_config_reference.h resetprg.c vecttbl.c vecttbl.h
  group src/smc_gen/r_bsp/doc/en
    src/smc_gen/r_bsp/doc/en/: r01an1685ej0360-rx.pdf
  group src/smc_gen/r_bsp/doc/ja
    src/smc_gen/r_bsp/doc/ja/: r01an1685jj0360-rx.pdf
  group src/smc_gen/r_bsp/mcu/all
    src/smc_gen/r_bsp/mcu/all/: r_bsp_common.c r_bsp_common.h r_typedefs.h
  group src/smc_gen/r_bsp/mcu/rx65n
    src/smc_gen/r_bsp/mcu/rx65n/: cpu.c cpu.h locking.c locking.h mcu_clocks.c mcu_info.h mcu_init.c mcu_init.h mcu_interrupts.c mcu_interrupts.h mcu_locks.c mcu_locks.h mcu_mapped_interrupts.c mcu_mapped_interrupts.h mcu_mapped_interrupts_private.h mcu_startup.c mcu_startup.h
  group src/smc_gen/r_bsp/mcu/rx65n/register_access
    src/smc_gen/r_bsp/mcu/rx65n/register_access/: iodefine.h
  group src/smc_gen/r_cmt_rx
    src/smc_gen/r_cmt_rx/: r_cmt_rx_if.h readme.txt
  group src/smc_gen/r_cmt_rx/doc/en
    src/smc_gen/r_cmt_rx/doc/en/: r01an1856ej0320-rx.pdf
  group src/smc_gen/r_cmt_rx/doc/ja
    src/smc_gen/r_cmt_rx/doc/ja/: r01an1856jj0320-rx.pdf
  group src/smc_gen/r_cmt_rx/ref
    src/smc_gen/r_cmt_rx/ref/: r_cmt_rx_config_reference.h
  group src/smc_gen/r_cmt_rx/src
    src/smc_gen/r_cmt_rx/src/: r_cmt_rx.c
  group src/smc_gen/r_config
    src/smc_gen/r_config/: r_bsp_config.h r_bsp_config_readme.txt r_bsp_interrupt_config.h r_cmt_rx_config.h r_flash_rx_config.h r_tfat_driver_rx_config.h r_tfat_rx_config.h r_usb_basic_config.h
  group src/smc_gen/r_flash_rx
    src/smc_gen/r_flash_rx/: r_flash_rx_if.h readme.txt
  group src/smc_gen/r_flash_rx/doc/en
    src/smc_gen/r_flash_rx/doc/en/: r01an2184eu0320-rx.pdf
  group src/smc_gen/r_flash_rx/doc/ja
    src/smc_gen/r_flash_rx/doc/ja/: r01an2184ju0320-rx.pdf
  group src/smc_gen/r_flash_rx/ref
    src/smc_gen/r_flash_rx/ref/: r_flash_rx_config_reference.h
  group src/smc_gen/r_flash_rx/src
    src/smc_gen/r_flash_rx/src/: r_flash_fcu.c r_flash_fcu.h r_flash_group.c r_flash_group.h r_flash_rx.c r_flash_rx.h r_flash_targets.h
  group src/smc_gen/r_flash_rx/src/flash_type_1
    src/smc_gen/r_flash_rx/src/flash_type_1/: r_codeflash.c r_codeflash.h r_codeflash_extra.c r_codeflash_extra.h r_dataflash.c r_dataflash.h r_flash_common.h r_flash_type1.c r_flash_type1_if.h r_flash_utils.c
  group src/smc_gen/r_flash_rx/src/flash_type_2
    src/smc_gen/r_flash_rx/src/flash_type_2/: r_flash_type2.c r_flash_type2_if.h
  group src/smc_gen/r_flash_rx/src/flash_type_3
    src/smc_gen/r_flash_rx/src/flash_type_3/: r_flash_type3.c r_flash_type3_if.h
  group src/smc_gen/r_flash_rx/src/flash_type_4
    src/smc_gen/r_flash_rx/src/flash_type_4/: r_flash_type4.c r_flash_type4_if.h
  group src/smc_gen/r_flash_rx/src/targets/rx65n
    src/smc_gen/r_flash_rx/src/targets/rx65n/: r_flash_rx65n.h r_mcu_config_reference.h
  group src/smc_gen/r_pincfg
    src/smc_gen/r_pincfg/: Pin.c Pin.h
  group src/smc_gen/r_tfat_driver_rx
    src/smc_gen/r_tfat_driver_rx/: r_tfat_driver_rx_if.h readme.txt
  group src/smc_gen/r_tfat_driver_rx/doc/en
    src/smc_gen/r_tfat_driver_rx/doc/en/: r20an0335ej0103-rx-tfat.pdf
  group src/smc_gen/r_tfat_driver_rx/doc/ja
    src/smc_gen/r_tfat_driver_rx/doc/ja/: r20an0335jj0103-rx-tfat.pdf
  group src/smc_gen/r_tfat_driver_rx/ref
    src/smc_gen/r_tfat_driver_rx/ref/: r_tfat_driver_rx_config_reference.h
  group src/smc_gen/r_tfat_driver_rx/src
    src/smc_gen/r_tfat_driver_rx/src/: r_tfat_drv_if.c r_tfat_drv_if_dev.h
  group src/smc_gen/r_tfat_driver_rx/src/device/sdhi
    src/smc_gen/r_tfat_driver_rx/src/device/sdhi/: r_tfat_drv_if_sdhi.c
  group src/smc_gen/r_tfat_driver_rx/src/device/usb
    src/smc_gen/r_tfat_driver_rx/src/device/usb/: r_tfat_drv_if_usb.c
  group src/smc_gen/r_tfat_driver_rx/src/device/usb_mini
    src/smc_gen/r_tfat_driver_rx/src/device/usb_mini/: r_tfat_drv_if_usb_mini.c
  group src/smc_gen/r_tfat_rx
    src/smc_gen/r_tfat_rx/: r_tfat_lib.h readme.txt
  group src/smc_gen/r_tfat_rx/doc/en
    src/smc_gen/r_tfat_rx/doc/en/: r20an0038ej0303-rx-tfat.pdf r20uw0078ej0301_tfat.pdf
  group src/smc_gen/r_tfat_rx/doc/ja
    src/smc_gen/r_tfat_rx/doc/ja/: r20an0038jj0303-rx-tfat.pdf r20uw0078jj0301_tfat.pdf
  group src/smc_gen/r_tfat_rx/lib
    src/smc_gen/r_tfat_rx/lib/: r_mw_version.h r_stdint.h tfat_rx200_big.lib tfat_rx200_little.lib tfat_rx600_big.lib tfat_rx600_little.lib
  group src/smc_gen/r_tfat_rx/ref
    src/smc_gen/r_tfat_rx/ref/: r_tfat_rx_config_reference.h
  group src/smc_gen/r_usb_basic
    src/smc_gen/r_usb_basic/: r_usb_basic_if.h readme.txt
  group src/smc_gen/r_usb_basic/doc/en
    src/smc_gen/r_usb_basic/doc/en/: r01an2025ej0122_usb.pdf
  group src/smc_gen/r_usb_basic/doc/ja
    src/smc_gen/r_usb_basic/doc/ja/: r01an2025jj0122_usb.pdf
  group src/smc_gen/r_usb_basic/ref
    src/smc_gen/r_usb_basic/ref/: r_usb_basic_config_reference.h
  group src/smc_gen/r_usb_basic/src/driver
    src/smc_gen/r_usb_basic/src/driver/: r_usb_cdataio.c r_usb_clibusbip.c r_usb_hbc.c r_usb_hcontrolrw.c r_usb_hdriver.c r_usb_hhubsys.c r_usb_hintfifo.c r_usb_hinthandler_usbip0.c r_usb_hinthandler_usbip1.c r_usb_hlibusbip.c r_usb_hmanager.c r_usb_hscheduler.c r_usb_hsignal.c r_usb_hstdfunction.c r_usb_pbc.c r_usb_pcontrolrw.c r_usb_pdriver.c r_usb_peptable.c r_usb_pintfifo.c r_usb_pinthandler_usbip0.c r_usb_plibusbip.c r_usb_psignal.c r_usb_pstdfunction.c r_usb_pstdrequest.c r_usb_usbif_api.c
  group src/smc_gen/r_usb_basic/src/driver/inc
    src/smc_gen/r_usb_basic/src/driver/inc/: r_usb_basic_define.h r_usb_extern.h r_usb_typedef.h
  group src/smc_gen/r_usb_basic/src/hw
    src/smc_gen/r_usb_basic/src/hw/: r_usb_creg_abs.c r_usb_creg_access.c r_usb_dma.c r_usb_hostelectrical.c r_usb_hreg_abs.c r_usb_hreg_access.c r_usb_preg_abs.c r_usb_preg_access.c r_usb_rx_mcu.c
  group src/smc_gen/r_usb_basic/src/hw/inc
    src/smc_gen/r_usb_basic/src/hw/inc/: r_usb_bitdefine.h r_usb_dmac.h r_usb_reg_access.h
  group src/smc_gen/r_usb_hmsc
    src/smc_gen/r_usb_hmsc/: r_usb_hmsc_if.h readme.txt
  group src/smc_gen/r_usb_hmsc/doc/en
    src/smc_gen/r_usb_hmsc/doc/en/: r01an2026ej0122_usb.pdf
  group src/smc_gen/r_usb_hmsc/doc/ja
    src/smc_gen/r_usb_hmsc/doc/ja/: r01an2026jj0122_usb.pdf
  group src/smc_gen/r_usb_hmsc/src
    src/smc_gen/r_usb_hmsc/src/: r_usb_hmsc_api.c r_usb_hmsc_driver.c r_usb_hstorage_driver.c r_usb_hstorage_driver_api.c
  group src/smc_gen/r_usb_hmsc/src/inc
    src/smc_gen/r_usb_hmsc/src/inc/: r_usb_hmsc.h
  group src/src
    src/src/: base64_decode.c base64_decode.h lcd_conf.c r_ascii.c r_ascii.h r_simple_graphic.c r_simple_graphic_if.h rx65n_secure_boot.c write.c
  group src/src/sha1/include
    src/src/sha1/include/: r_cryptogram.h r_stdint.h
  group src/src/sha1/lib
    src/src/sha1/lib/: sha1.c sha1_rx_big_v100.lib sha1_rx_little_v100.lib

# IAR project rx65n_envision_benchmark.ewp, settings and files
configuration Motorola output (RX)
  General.OGChipSelectMenu: R5F565NE_DUAL R5F565NE_DUAL
  General.GenCodeModel: 0
  General.GenDataModel: 2
  General.StackSize: 0x0
  General.IStackSize: 0x1000
  General.HeapSize: 0x4000
  ICCRX.CCDefines: __RX
  ICCRX.CCDiagSuppress: Pa082,Pe111,Pe226,Pa089,Pa182,Pa084,Pa093,Pa050,Pe009,Pe301,Pe167,Pe513,Pe177
  ICCRX.CCIncludePath2: src\smc_gen\r_bsp; src\smc_gen\r_config; src\smc_gen\r_cmt_rx; src\smc_gen\r_cmt_rx\src; src\smc_gen\r_ether_rx; src\smc_gen\r_flash_rx; src\smc_gen\r_flash_rx\src; src\smc_gen\r_flash_rx\src\flash_type_1; src\smc_gen\r_flash_rx\src\flash_type_2; src\smc_gen\r_flash_rx\src\flash_type_3; src\smc_gen\r_flash_rx\src\flash_type_4; src\smc_gen\r_flash_rx\src\targets; src\smc_gen\r_glcdc_rx; src\smc_gen\r_gpio_rx; src\smc_gen\r_gpio_rx\src; src\smc_gen\r_mpc_rx; src\smc_gen\r_mpc_rx\src; src\smc_gen\r_sci_iic_rx; src\smc_gen\r_sci_iic_rx\src; src\smc_gen\r_sys_time_rx; src\smc_gen\r_sys_time_rx\src; src\smc_gen\r_t4_driver_rx; src\smc_gen\r_t4_driver_rx\src; src\smc_gen\r_t4_rx; src\smc_gen\r_t4_rx\lib; src\smc_gen\r_tfat_driver_rx; src\smc_gen\r_tfat_driver_rx\src; src\smc_gen\r_tfat_driver_rx\src\device\sdhi; src\smc_gen\r_tfat_driver_rx\src\device\usb; src\smc_gen\r_tfat_driver_rx\src\device\usb_mini; src\smc_gen\r_tfat_rx; src\smc_gen\r_tfat_rx\lib; src\smc_gen\r_usb_basic; src\smc_gen\r_usb_basic\src\driver\inc; src\smc_gen\r_usb_basic\src\hw\inc; src\smc_gen\r_usb_hmsc; src\smc_gen\r_usb_hmsc\src\inc; src\smc_gen\r_t4_dns_client_rx; src\smc_gen\r_t4_dns_client_rx\src; src\smc_gen\r_t4_file_driver_rx; src\smc_gen\r_t4_file_driver_rx\src; src\smc_gen\r_t4_file_driver_rx\src\use_external_mem; src\smc_gen\r_t4_file_driver_rx\src\use_internal_mem; src\smc_gen\r_t4_ftp_server_rx; src\smc_gen\r_t4_ftp_server_rx\src; src\smc_gen\r_t4_http_server_rx; src\smc_gen\r_t4_http_server_rx\src; src\smc_gen\r_t4_sntp_client_rx; src\smc_gen\r_t4_sntp_client_rx\src; src\smc_gen\general; src\smc_gen\r_pincfg; src\src\Config; src\src; src\src\GUI; src\src\guibuilder_output; src\src\sha_lib
  ICCRX.IccExtraOptions: --enum_is_int
  ICCRX.IccLang: 0
  OBJCOPY.OOCOutputFile: rx65n_envision_benchmark.mot
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: benchmark.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (RX, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: rx65n_envision_benchmark.srec
  ILINK.IlinkIcfFile: benchmark_debug.icf
  group (top)
    ./: benchmark.icf benchmark_debug.icf rx65n_envision.ddf
  group src/smc_gen/general
    src/smc_gen/general/: r_cg_bsc.h r_cg_cac.h r_cg_cmt.h r_cg_cmtw.h r_cg_crc.h r_cg_dmac.h r_cg_dmac_user.c r_cg_doc.h r_cg_dtc.h r_cg_elc.h r_cg_hardware_setup.c r_cg_icu.h r_cg_iwdt.h r_cg_lpc.h r_cg_lvd.h r_cg_macrodriver.h r_cg_mtu3.h r_cg_poe.h r_cg_port.h r_cg_ppg.h r_cg_r12da.h r_cg_riic.h r_cg_rspi.h r_cg_rtc.h r_cg_s12ad.h r_cg_sci.h r_cg_tmr.h r_cg_tpu.h r_cg_userdefine.h r_cg_wdt.h r_smc_cgc.c r_smc_cgc.h r_smc_cgc_user.c r_smc_entry.h r_smc_interrupt.c r_smc_interrupt.h
  group src/smc_gen/r_bsp
    src/smc_gen/r_bsp/: platform.h readme.txt
  group src/smc_gen/r_bsp/board/generic_rx65n
    src/smc_gen/r_bsp/board/generic_rx65n/: hwsetup.c hwsetup.h r_bsp.h r_bsp_config_reference.h r_bsp_interrupt_config_reference.h resetprg.c vecttbl.c vecttbl.h
  group src/smc_gen/r_bsp/doc/en
    src/smc_gen/r_bsp/doc/en/: r01an1685ej0360-rx.pdf
  group src/smc_gen/r_bsp/doc/ja
    src/smc_gen/r_bsp/doc/ja/: r01an1685jj0360-rx.pdf
  group src/smc_gen/r_bsp/mcu/all
    src/smc_gen/r_bsp/mcu/all/: r_bsp_common.c r_bsp_common.h r_typedefs.h
  group src/smc_gen/r_bsp/mcu/rx65n
    src/smc_gen/r_bsp/mcu/rx65n/: cpu.c cpu.h locking.c locking.h mcu_clocks.c mcu_info.h mcu_init.c mcu_init.h mcu_interrupts.c mcu_interrupts.h mcu_locks.c mcu_locks.h mcu_mapped_interrupts.c mcu_mapped_interrupts.h mcu_mapped_interrupts_private.h mcu_startup.c mcu_startup.h
  group src/smc_gen/r_bsp/mcu/rx65n/register_access
    src/smc_gen/r_bsp/mcu/rx65n/register_access/: iodefine.h
  group src/smc_gen/r_cmt_rx
    src/smc_gen/r_cmt_rx/: r_cmt_rx_if.h readme.txt
  group src/smc_gen/r_cmt_rx/doc/en
    src/smc_gen/r_cmt_rx/doc/en/: r01an1856ej0320-rx.pdf
  group src/smc_gen/r_cmt_rx/doc/ja
    src/smc_gen/r_cmt_rx/doc/ja/: r01an1856jj0320-rx.pdf
  group src/smc_gen/r_cmt_rx/ref
    src/smc_gen/r_cmt_rx/ref/: r_cmt_rx_config_reference.h
  group src/smc_gen/r_cmt_rx/src
    src/smc_gen/r_cmt_rx/src/: r_cmt_rx.c
  group src/smc_gen/r_config
    src/smc_gen/r_config/: r_bsp_config.h r_bsp_config_readme.txt r_bsp_interrupt_config.h r_cmt_rx_config.h r_ether_rx_config.h r_flash_rx_config.h r_glcdc_rx_config.h r_gpio_rx_config.h r_mpc_rx_config.h r_sci_iic_rx_config.h r_sci_iic_rx_pin_config.h r_sdhi_rx_config.h r_sys_time_rx_config.h r_t4_dns_client_rx_config.h r_t4_driver_rx_config.h r_t4_file_driver_rx_config.h r_t4_ftp_server_rx_config.h r_t4_http_server_rx_config.h r_t4_rx_config.h r_t4_sntp_client_rx_config.h r_tfat_driver_rx_config.h r_tfat_rx_config.h r_usb_basic_config.h
  group src/smc_gen/r_ether_rx
    src/smc_gen/r_ether_rx/: r_ether_rx_if.h readme.txt
  group src/smc_gen/r_ether_rx/doc/en
    src/smc_gen/r_ether_rx/doc/en/: r01an2009ej0113-rx.pdf
  group src/smc_gen/r_ether_rx/doc/ja
    src/smc_gen/r_ether_rx/doc/ja/: r01an2009jj0113-rx.pdf
  group src/smc_gen/r_ether_rx/ref
    src/smc_gen/r_ether_rx/ref/: r_ether_rx_config_reference.h
  group src/smc_gen/r_ether_rx/src
    src/smc_gen/r_ether_rx/src/: r_ether_rx.c r_ether_rx_private.h
  group src/smc_gen/r_ether_rx/src/phy
    src/smc_gen/r_ether_rx/src/phy/: phy.c phy.h
  group src/smc_gen/r_ether_rx/src/targets/rx65n
    src/smc_gen/r_ether_rx/src/targets/rx65n/: r_ether_setting_rx65n.c
  group src/smc_gen/r_flash_rx
    src/smc_gen/r_flash_rx/: r_flash_rx_if.h readme.txt
  group src/smc_gen/r_flash_rx/doc/en
    src/smc_gen/r_flash_rx/doc/en/: r01an2184eu0320-rx.pdf
  group src/smc_gen/r_flash_rx/doc/ja
    src/smc_gen/r_flash_rx/doc/ja/: r01an2184ju0320-rx.pdf
  group src/smc_gen/r_flash_rx/ref
    src/smc_gen/r_flash_rx/ref/: r_flash_rx_config_reference.h
  group src/smc_gen/r_flash_rx/src
    src/smc_gen/r_flash_rx/src/: r_flash_fcu.c r_flash_fcu.h r_flash_group.c r_flash_group.h r_flash_rx.c r_flash_rx.h r_flash_targets.h
  group src/smc_gen/r_flash_rx/src/flash_type_1
    src/smc_gen/r_flash_rx/src/flash_type_1/: r_codeflash.c r_codeflash.h r_codeflash_extra.c r_codeflash_extra.h r_dataflash.c r_dataflash.h r_flash_common.h r_flash_type1.c r_flash_type1_if.h r_flash_utils.c
  group src/smc_gen/r_flash_rx/src/flash_type_2
    src/smc_gen/r_flash_rx/src/flash_type_2/: r_flash_type2.c r_flash_type2_if.h
  group src/smc_gen/r_flash_rx/src/flash_type_3
    src/smc_gen/r_flash_rx/src/flash_type_3/: r_flash_type3.c r_flash_type3_if.h
  group src/smc_gen/r_flash_rx/src/flash_type_4
    src/smc_gen/r_flash_rx/src/flash_type_4/: r_flash_type4.c r_flash_type4_if.h
  group src/smc_gen/r_flash_rx/src/targets/rx65n
    src/smc_gen/r_flash_rx/src/targets/rx65n/: r_flash_rx65n.h r_mcu_config_reference.h
  group src/smc_gen/r_glcdc_rx
    src/smc_gen/r_glcdc_rx/: r_glcdc_rx_if.h readme.txt
  group src/smc_gen/r_glcdc_rx/doc/en
    src/smc_gen/r_glcdc_rx/doc/en/: r01an3609ej0100-rx.pdf
  group src/smc_gen/r_glcdc_rx/doc/ja
    src/smc_gen/r_glcdc_rx/doc/ja/: r01an3609jj0100-rx.pdf
  group src/smc_gen/r_glcdc_rx/ref
    src/smc_gen/r_glcdc_rx/ref/: r_glcdc_rx_config_reference.h
  group src/smc_gen/r_glcdc_rx/src
    src/smc_gen/r_glcdc_rx/src/: r_glcdc_private.c r_glcdc_private.h r_glcdc_rx.c
  group src/smc_gen/r_glcdc_rx/src/targets/rx65n
    src/smc_gen/r_glcdc_rx/src/targets/rx65n/: r_glcdc_rx65n.c
  group src/smc_gen/r_gpio_rx
    src/smc_gen/r_gpio_rx/: r_gpio_rx_if.h readme.txt
  group src/smc_gen/r_gpio_rx/doc/en
    src/smc_gen/r_gpio_rx/doc/en/: r01an1721ej0230-rx.pdf
  group src/smc_gen/r_gpio_rx/doc/ja
    src/smc_gen/r_gpio_rx/doc/ja/: r01an1721jj0230-rx.pdf
  group src/smc_gen/r_gpio_rx/ref
    src/smc_gen/r_gpio_rx/ref/: r_gpio_rx_config_reference.h
  group src/smc_gen/r_gpio_rx/src
    src/smc_gen/r_gpio_rx/src/: r_gpio_rx.c
  group src/smc_gen/r_gpio_rx/src/targets/rx65n
    src/smc_gen/r_gpio_rx/src/targets/rx65n/: r_gpio_rx65n.c r_gpio_rx65n.h
  group src/smc_gen/r_mpc_rx
    src/smc_gen/r_mpc_rx/: r_mpc_rx_if.h readme.txt
  group src/smc_gen/r_mpc_rx/doc/en
    src/smc_gen/r_mpc_rx/doc/en/: r01an1724ej0230-rx.pdf
  group src/smc_gen/r_mpc_rx/doc/ja
    src/smc_gen/r_mpc_rx/doc/ja/: r01an1724jj0230-rx.pdf
  group src/smc_gen/r_mpc_rx/ref
    src/smc_gen/r_mpc_rx/ref/: r_mpc_rx_config_reference.h
  group src/smc_gen/r_mpc_rx/src
    src/smc_gen/r_mpc_rx/src/: r_mpc_rx.c
  group src/smc_gen/r_pincfg
    src/smc_gen/r_pincfg/: Pin.c Pin.h r_ether_rx_pinset.c r_ether_rx_pinset.h r_glcdc_rx_pinset.c r_glcdc_rx_pinset.h r_pinset.h
  group src/smc_gen/r_sci_iic_rx
    src/smc_gen/r_sci_iic_rx/: r_sci_iic_rx_if.h readme.txt
  group src/smc_gen/r_sci_iic_rx/doc/en
    src/smc_gen/r_sci_iic_rx/doc/en/: r01an1691ej0220-rx.pdf
  group src/smc_gen/r_sci_iic_rx/doc/ja
    src/smc_gen/r_sci_iic_rx/doc/ja/: r01an1691jj0220-rx.pdf
  group src/smc_gen/r_sci_iic_rx/ref
    src/smc_gen/r_sci_iic_rx/ref/: r_sci_iic_rx_config_reference.h r_sci_iic_rx_pin_config_reference.h
  group src/smc_gen/r_sci_iic_rx/src
    src/smc_gen/r_sci_iic_rx/src/: r_sci_iic_rx.c r_sci_iic_rx_platform.h r_sci_iic_rx_private.h
  group src/smc_gen/r_sci_iic_rx/src/targets/rx65n
    src/smc_gen/r_sci_iic_rx/src/targets/rx65n/: r_sci_iic_rx65n.c r_sci_iic_rx65n_private.h
  group src/smc_gen/r_sys_time_rx
    src/smc_gen/r_sys_time_rx/: r_sys_time_rx_if.h readme.txt
  group src/smc_gen/r_sys_time_rx/doc/en
    src/smc_gen/r_sys_time_rx/doc/en/: r20an0431ej0100-rx-middle.pdf
  group src/smc_gen/r_sys_time_rx/doc/ja
    src/smc_gen/r_sys_time_rx/doc/ja/: r20an0431jj0100-rx-middle.pdf
  group src/smc_gen/r_sys_time_rx/ref
    src/smc_gen/r_sys_time_rx/ref/: r_sys_time_rx_config_reference.h
  group src/smc_gen/r_sys_time_rx/src
    src/smc_gen/r_sys_time_rx/src/: r_sys_time_rx.c r_sys_time_rx_private.h
  group src/smc_gen/r_t4_dns_client_rx
    src/smc_gen/r_t4_dns_client_rx/: r_t4_dns_client_rx_if.h readme.txt
  group src/smc_gen/r_t4_dns_client_rx/ref
    src/smc_gen/r_t4_dns_client_rx/ref/: r_t4_dns_client_rx_config_reference.h
  group src/smc_gen/r_t4_dns_client_rx/src
    src/smc_gen/r_t4_dns_client_rx/src/: r_dns_client.c r_dns_client.h
  group src/smc_gen/r_t4_driver_rx
    src/smc_gen/r_t4_driver_rx/: readme.txt
  group src/smc_gen/r_t4_driver_rx/doc/en
    src/smc_gen/r_t4_driver_rx/doc/en/: r20an0311ej0106-rx-t4.pdf
  group src/smc_gen/r_t4_driver_rx/doc/ja
    src/smc_gen/r_t4_driver_rx/doc/ja/: r20an0311jj0106-rx-t4.pdf
  group src/smc_gen/r_t4_driver_rx/ref
    src/smc_gen/r_t4_driver_rx/ref/: r_t4_driver_rx_config_reference.h
  group src/smc_gen/r_t4_driver_rx/src
    src/smc_gen/r_t4_driver_rx/src/: ether_callback.c t4_driver.c timer.c timer.h
  group src/smc_gen/r_t4_file_driver_rx
    src/smc_gen/r_t4_file_driver_rx/: r_t4_file_driver_rx_if.h readme.txt
  group src/smc_gen/r_t4_file_driver_rx/doc/en
    src/smc_gen/r_t4_file_driver_rx/doc/en/: r20an0333ej0102-rx-t4.pdf
  group src/smc_gen/r_t4_file_driver_rx/doc/ja
    src/smc_gen/r_t4_file_driver_rx/doc/ja/: r20an0333jj0102-rx-t4.pdf
  group src/smc_gen/r_t4_file_driver_rx/ref
    src/smc_gen/r_t4_file_driver_rx/ref/: r_t4_file_driver_rx_config_reference.h
  group src/smc_gen/r_t4_file_driver_rx/src
    src/smc_gen/r_t4_file_driver_rx/src/: r_file_driver.c r_file_driver.h
  group src/smc_gen/r_t4_file_driver_rx/src/use_external_mem
    src/smc_gen/r_t4_file_driver_rx/src/use_external_mem/: r_file_driver_external.c
  group src/smc_gen/r_t4_file_driver_rx/src/use_internal_mem
    src/smc_gen/r_t4_file_driver_rx/src/use_internal_mem/: r_file_driver_internal.c
  group src/smc_gen/r_t4_ftp_server_rx
    src/smc_gen/r_t4_ftp_server_rx/: r_t4_ftp_server_rx_if.h readme.txt
  group src/smc_gen/r_t4_ftp_server_rx/doc/en
    src/smc_gen/r_t4_ftp_server_rx/doc/en/: r20an0078ej0104-rx-t4.pdf
  group src/smc_gen/r_t4_ftp_server_rx/doc/ja
    src/smc_gen/r_t4_ftp_server_rx/doc/ja/: r20an0078jj0104-rx-t4.pdf
  group src/smc_gen/r_t4_ftp_server_rx/ref
    src/smc_gen/r_t4_ftp_server_rx/ref/: r_t4_ftp_server_rx_config_reference.h
  group src/smc_gen/r_t4_ftp_server_rx/src
    src/smc_gen/r_t4_ftp_server_rx/src/: r_ftp_server.c
  group src/smc_gen/r_t4_http_server_rx
    src/smc_gen/r_t4_http_server_rx/: r_t4_http_server_rx_if.h readme.txt
  group src/smc_gen/r_t4_http_server_rx/doc/en
    src/smc_gen/r_t4_http_server_rx/doc/en/: r20an0075ej0105-rx-t4.pdf
  group src/smc_gen/r_t4_http_server_rx/doc/ja
    src/smc_gen/r_t4_http_server_rx/doc/ja/: r20an0075jj0105-rx-t4.pdf
  group src/smc_gen/r_t4_http_server_rx/ref
    src/smc_gen/r_t4_http_server_rx/ref/: r_t4_http_server_rx_config_reference.h
  group src/smc_gen/r_t4_http_server_rx/src
    src/smc_gen/r_t4_http_server_rx/src/: r_http_server.c r_http_server_config.c r_http_server_config.h
  group src/smc_gen/r_t4_rx
    src/smc_gen/r_t4_rx/: readme.txt
  group src/smc_gen/r_t4_rx/doc/en
    src/smc_gen/r_t4_rx/doc/en/: r20an0051ej0206-rx-t4.pdf r20uw0031ej0109-t4tiny.pdf r20uw0032ej0108-t4tiny.pdf
  group src/smc_gen/r_t4_rx/doc/ja
    src/smc_gen/r_t4_rx/doc/ja/: r20an0051jj0206-rx-t4.pdf r20uw0031jj0109-t4tiny.pdf r20uw0032jj0108-t4tiny.pdf
  group src/smc_gen/r_t4_rx/lib
    src/smc_gen/r_t4_rx/lib/: r_mw_version.h r_stdint.h r_t4_itcpip.h T4_Library_rxv1_ether_big.lib T4_Library_rxv1_ether_big_debug.lib T4_Library_rxv1_ether_little.lib T4_Library_rxv1_ether_little_debug.lib
  group src/smc_gen/r_t4_rx/ref
    src/smc_gen/r_t4_rx/ref/: r_t4_rx_config_reference.h
  group src/smc_gen/r_t4_rx/src
    src/smc_gen/r_t4_rx/src/: config_tcpudp.c
  group src/smc_gen/r_t4_sntp_client_rx
    src/smc_gen/r_t4_sntp_client_rx/: r_t4_sntp_client_rx_if.h readme.txt
  group src/smc_gen/r_t4_sntp_client_rx/ref
    src/smc_gen/r_t4_sntp_client_rx/ref/: r_t4_sntp_client_rx_config_reference.h
  group src/smc_gen/r_t4_sntp_client_rx/src
    src/smc_gen/r_t4_sntp_client_rx/src/: r_sntp_client.c r_sntp_client.h
  group src/smc_gen/r_tfat_driver_rx
    src/smc_gen/r_tfat_driver_rx/: r_tfat_driver_rx_if.h readme.txt
  group src/smc_gen/r_tfat_driver_rx/doc/en
    src/smc_gen/r_tfat_driver_rx/doc/en/: r20an0335ej0103-rx-tfat.pdf
  group src/smc_gen/r_tfat_driver_rx/doc/ja
    src/smc_gen/r_tfat_driver_rx/doc/ja/: r20an0335jj0103-rx-tfat.pdf
  group src/smc_gen/r_tfat_driver_rx/ref
    src/smc_gen/r_tfat_driver_rx/ref/: r_tfat_driver_rx_config_reference.h
  group src/smc_gen/r_tfat_driver_rx/src
    src/smc_gen/r_tfat_driver_rx/src/: r_tfat_drv_if.c r_tfat_drv_if_dev.h
  group src/smc_gen/r_tfat_driver_rx/src/device/sdhi
    src/smc_gen/r_tfat_driver_rx/src/device/sdhi/: r_tfat_drv_if_sdhi.c
  group src/smc_gen/r_tfat_driver_rx/src/device/usb
    src/smc_gen/r_tfat_driver_rx/src/device/usb/: r_tfat_drv_if_usb.c
  group src/smc_gen/r_tfat_driver_rx/src/device/usb_mini
    src/smc_gen/r_tfat_driver_rx/src/device/usb_mini/: r_tfat_drv_if_usb_mini.c
  group src/smc_gen/r_tfat_rx
    src/smc_gen/r_tfat_rx/: r_tfat_lib.h readme.txt
  group src/smc_gen/r_tfat_rx/doc/en
    src/smc_gen/r_tfat_rx/doc/en/: r20an0038ej0303-rx-tfat.pdf r20uw0078ej0301_tfat.pdf
  group src/smc_gen/r_tfat_rx/doc/ja
    src/smc_gen/r_tfat_rx/doc/ja/: r20an0038jj0303-rx-tfat.pdf r20uw0078jj0301_tfat.pdf
  group src/smc_gen/r_tfat_rx/lib
    src/smc_gen/r_tfat_rx/lib/: r_mw_version.h r_stdint.h tfat_rx200_big.lib tfat_rx200_little.lib tfat_rx600_big.lib tfat_rx600_little.lib
  group src/smc_gen/r_tfat_rx/ref
    src/smc_gen/r_tfat_rx/ref/: r_tfat_rx_config_reference.h
  group src/smc_gen/r_usb_basic
    src/smc_gen/r_usb_basic/: r_usb_basic_if.h readme.txt
  group src/smc_gen/r_usb_basic/doc/en
    src/smc_gen/r_usb_basic/doc/en/: r01an2025ej0122_usb.pdf
  group src/smc_gen/r_usb_basic/doc/ja
    src/smc_gen/r_usb_basic/doc/ja/: r01an2025jj0122_usb.pdf
  group src/smc_gen/r_usb_basic/ref
    src/smc_gen/r_usb_basic/ref/: r_usb_basic_config_reference.h
  group src/smc_gen/r_usb_basic/src/driver
    src/smc_gen/r_usb_basic/src/driver/: r_usb_cdataio.c r_usb_clibusbip.c r_usb_hbc.c r_usb_hcontrolrw.c r_usb_hdriver.c r_usb_hhubsys.c r_usb_hintfifo.c r_usb_hinthandler_usbip0.c r_usb_hinthandler_usbip1.c r_usb_hlibusbip.c r_usb_hmanager.c r_usb_hscheduler.c r_usb_hsignal.c r_usb_hstdfunction.c r_usb_pbc.c r_usb_pcontrolrw.c r_usb_pdriver.c r_usb_peptable.c r_usb_pintfifo.c r_usb_pinthandler_usbip0.c r_usb_plibusbip.c r_usb_psignal.c r_usb_pstdfunction.c r_usb_pstdrequest.c r_usb_usbif_api.c
  group src/smc_gen/r_usb_basic/src/driver/inc
    src/smc_gen/r_usb_basic/src/driver/inc/: r_usb_basic_define.h r_usb_extern.h r_usb_typedef.h
  group src/smc_gen/r_usb_basic/src/hw
    src/smc_gen/r_usb_basic/src/hw/: r_usb_creg_abs.c r_usb_creg_access.c r_usb_dma.c r_usb_hostelectrical.c r_usb_hreg_abs.c r_usb_hreg_access.c r_usb_preg_abs.c r_usb_preg_access.c r_usb_rx_mcu.c
  group src/smc_gen/r_usb_basic/src/hw/inc
    src/smc_gen/r_usb_basic/src/hw/inc/: r_usb_bitdefine.h r_usb_dmac.h r_usb_reg_access.h
  group src/smc_gen/r_usb_hmsc
    src/smc_gen/r_usb_hmsc/: r_usb_hmsc_if.h readme.txt
  group src/smc_gen/r_usb_hmsc/doc/en
    src/smc_gen/r_usb_hmsc/doc/en/: r01an2026ej0122_usb.pdf
  group src/smc_gen/r_usb_hmsc/doc/ja
    src/smc_gen/r_usb_hmsc/doc/ja/: r01an2026jj0122_usb.pdf
  group src/smc_gen/r_usb_hmsc/src
    src/smc_gen/r_usb_hmsc/src/: r_usb_hmsc_api.c r_usb_hmsc_driver.c r_usb_hstorage_driver.c r_usb_hstorage_driver_api.c
  group src/smc_gen/r_usb_hmsc/src/inc
    src/smc_gen/r_usb_hmsc/src/inc/: r_usb_hmsc.h
  group src/src
    src/src/: base64_decode.c base64_decode.h benchmark.c benchmark.h firm_update.c main.c rpbrx65n_2mb.h
  group src/src/Config
    src/src/Config/: GUI_X_Ex.c GUIConf.c GUIConf.h LCDConf.c LCDConf.h PIDConf.c PIDConf.h
  group src/src/GUI
    src/src/GUI/: BUTTON.h BUTTON_Private.h CALENDAR.h CHECKBOX.h CHECKBOX_Private.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Intern.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h emWinLib.lib FRAMEWIN.h FRAMEWIN_Private.h Global.h GRAPH.h GRAPH_Private.h GUI.h GUI__BiDi2_Brackets_800.h GUI__BiDi2_Types_800.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GCache_Private.h GUI_GIF_Private.h GUI_HOOK.h GUI_JPEG_Private.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_SPRITE_Private.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_Lin.h GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_24.h GUIDRV_Lin_Opt_32.h GUIDRV_Lin_Opt_8.h GUIDRV_Lin_Private.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h IMAGE.h IMAGE_Private.h IP_FS.h KNOB.h KNOB_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h RADIO.h RADIO_Private.h SCROLLBAR.h SCROLLBAR_Private.h SEGGER.h SLIDER.h SLIDER_Private.h SPINBOX.h SPINBOX_Private.h SWIPELIST.h SWIPELIST_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h
  group src/src/GUI/Doc
    src/src/GUI/Doc/: License.txt UM03001_emWin5.pdf
  group src/src/guibuilder_output
    src/src/guibuilder_output/: FrameWindowDLG.c NetworkStatWindowDLG.c SecureUpdateWindowDLG.c StorageBenchmarkDLG.c SystemLogWindowDLG.c TitleLogoWindowDLG.c
  group src/src/sha_lib
    src/src/sha_lib/: r_cryptogram.h r_stdint.h sha1_rx_big_v100.lib sha1_rx_little_v100.lib

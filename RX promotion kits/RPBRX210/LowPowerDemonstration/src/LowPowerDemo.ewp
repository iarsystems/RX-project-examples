# IAR project LowPowerDemo.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F52108A R5F52108A
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: Debug
  ICCRX.CCIncludePath2: $PROJ_DIR$
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group C source file
    ./: main.c PowerTests.c resetprg.c s12ad.c setupclocks.c

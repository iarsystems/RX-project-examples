# IAR project RPBRX71M_GAPI.ewp, settings and files
configuration HardwareDebugRPBRX71M (RX, debug)
  General.OGChipSelectMenu: R5F571ML R5F571ML
  General.GenCodeModel: 0
  General.GenDataModel: 2
  General.StackSize: 0x1100
  General.IStackSize: 0x400
  General.HeapSize: 0x3FFF
  ICCRX.CCDefines: __RX; __RX600; RPBRX71M_BUILD
  ICCRX.CCDiagSuppress: Pa050,Pe009,Pe301,Pe1665,Pa082,Pe223,Pe177,Ta014,Pa084,Pe188,Pa093,Pe108,Pa092
  ICCRX.CCIncludePath2: CommonSource; CommonSource/Jpeg; CommonSource/usb_pmsc; CommonSource/SerialFlashStubs; CommonSource/usb_media/data_flash_disk; r_bsp; r_bsp/board/rpbrx71m; r_bsp/mcu/rx71m; r_bsp/mcu/rx71m/register_access; r_config; r_Packages/r_ddlcd; r_Packages/r_freertos; r_Packages/r_freertos/portable/IAR/RX600; r_Packages/r_gapi; r_Packages/config; r_flash_rx; r_flash_rx/src; r_flash_rx/src/flash_type_1; r_flash_rx/src/flash_type_2; r_flash_rx/src/flash_type_3; r_flash_rx/src/targets; r_tfat_rx; r_tfat_rx/lib; r_usb_basic; r_usb_basic/src/driver/inc; r_usb_basic/src/HW/inc; r_usb_pmsc; r_usb_pmsc/src/inc; r_flash_rx/src/flash_type_4
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkKeepSymbols: Resources
  ILINK.IlinkIcfFile: lnkr5f571ml_LCD.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: ProjectConnection.ipcf
  group CommonSource
    CommonSource/: ad_dtc_RX71M.c ad_dtc_RX71M.h crc.c dtc_vect_RX.h EventMgr.c FindFile.c FindFile.h Frames.c Frames.h FreeRTOS_Callback.c Global.h iresources.h LCD_demo.h main.c r_config_demo_mode.c r_config_demo_mode.h r_config_parse.c r_config_parse.h r_touch_sim_stimuli.h r_touch_simulate.c r_touch_simulate.h Resources.c ScreenAnimate.c ScreenCalibrate.c ScreenCard.c ScreenCountdown.c ScreenHome.c ScreenHomeClassic.c ScreenIO.c ScreenMed.c ScreenMgr.c ScreenMgr.h ScreenObjs.c ScreenObjs.h ScreenQWERTY.c ScreenRefrig.c ScreenSlider.c ScreenThermo.c ScreenUTF.c ScreenWrites.c simple_printf.c timer_rtc.c timer_rtc.h touchscreen.c touchscreen.h UTF_strings.h
  group CommonSource/Jpeg
    CommonSource/Jpeg/: expand_jpegd_rx600_little.lib jpegd_rx600_little.lib r_expand_jpegd.h r_jpegd.h r_mw_version.h r_stdint.h
  group CommonSource/SerialFlashStubs
    CommonSource/SerialFlashStubs/: FlashSerialStubs.c FlashSerialStubs.h
  group CommonSource/usb_media/data_flash_disk
    CommonSource/usb_media/data_flash_disk/: r_tfat_dataflash_media.c r_usb_dataflash_disk.c r_usb_dataflash_disk.h r_usb_dataflash_disk_format.c
  group CommonSource/usb_pmsc
    CommonSource/usb_pmsc/: r_usb_pmsc_apl.c r_usb_pmsc_apl.h r_usb_pmsc_descriptor.c
  group doc
    doc/: description.txt
  group FIT Modules/r_flash_rx
    r_flash_rx/: r_flash_rx_if.h readme.txt
  group FIT Modules/r_flash_rx/doc
    r_flash_rx/doc/: r01an2184eu0170_rx.pdf
  group FIT Modules/r_flash_rx/ref
    r_flash_rx/ref/: r_flash_rx_config_reference.h
  group FIT Modules/r_flash_rx/src
    r_flash_rx/src/: r_flash_rx.c r_flash_rx.h
  group FIT Modules/r_flash_rx/src/flash_type_1
    r_flash_rx/src/flash_type_1/: r_codeflash.c r_codeflash.h r_codeflash_extra.c r_codeflash_extra.h r_dataflash.c r_dataflash.h r_flash_common.h r_flash_type1.c r_flash_type1_if.h r_flash_utils.c
  group FIT Modules/r_flash_rx/src/flash_type_2
    r_flash_rx/src/flash_type_2/: r_flash_type2.c r_flash_type2_if.h
  group FIT Modules/r_flash_rx/src/flash_type_3
    r_flash_rx/src/flash_type_3/: r_flash_type3.c r_flash_type3_if.h
  group FIT Modules/r_flash_rx/src/flash_type_4
    r_flash_rx/src/flash_type_4/: r_flash_type4.c r_flash_type4_if.h
  group FIT Modules/r_flash_rx/src/targets/rx71m
    r_flash_rx/src/targets/rx71m/: r_flash_rx71m.h
  group FIT Modules/r_tfat_rx
    r_tfat_rx/: r_tfat_lib.h readme.txt
  group FIT Modules/r_tfat_rx/doc/en
    r_tfat_rx/doc/en/: r20an0038ej0302_rx_tfat.pdf r20uw0078ej0301_tfat.pdf
  group FIT Modules/r_tfat_rx/doc/ja
    r_tfat_rx/doc/ja/: r20an0038jj0302_rx_tfat.pdf r20uw0078jj0301_tfat.pdf
  group FIT Modules/r_tfat_rx/lib
    r_tfat_rx/lib/: r_mw_version.h r_stdint.h tfat_rx600_little.lib
  group FIT Modules/r_tfat_rx/ref
    r_tfat_rx/ref/: r_tfat_rx_config_reference.h
  group FIT Modules/r_usb_basic
    r_usb_basic/: r_usb_basic_if.h readme.txt
  group FIT Modules/r_usb_basic/doc
    r_usb_basic/doc/: r01an2025ej0110_usb.pdf
  group FIT Modules/r_usb_basic/ref
    r_usb_basic/ref/: r_usb_basic_config_reference.h
  group FIT Modules/r_usb_basic/src/driver/comm
    r_usb_basic/src/driver/comm/: r_usb_cdataio.c r_usb_cintfifo.c r_usb_cinthandler_usbip0.c r_usb_cinthandler_usbip1.c r_usb_clibusbip.c r_usb_cscheduler.c r_usb_cstdapi.c r_usb_cstdfunction.c
  group FIT Modules/r_usb_basic/src/driver/host
    r_usb_basic/src/driver/host/: r_usb_hbc.c r_usb_hcontrolrw.c r_usb_hdriver.c r_usb_hdriverapi.c r_usb_hhubsys.c r_usb_hintfifo.c r_usb_hlibusbip.c r_usb_hmanager.c r_usb_hsignal.c r_usb_hstdfunction.c
  group FIT Modules/r_usb_basic/src/driver/inc
    r_usb_basic/src/driver/inc/: r_usb_api.h r_usb_cdefusbip.h r_usb_cextern.h r_usb_ckernelid.h r_usb_cmacprint.h r_usb_cmacsystemcall.h r_usb_ctypedef.h
  group FIT Modules/r_usb_basic/src/driver/peri
    r_usb_basic/src/driver/peri/: r_usb_pbc.c r_usb_pcontrolrw.c r_usb_pdriver.c r_usb_pdriverapi.c r_usb_pintfifo.c r_usb_psignal.c r_usb_pstdfunction.c r_usb_pstdrequest.c
  group FIT Modules/r_usb_basic/src/HW
    r_usb_basic/src/HW/: RX64M.txt
  group FIT Modules/r_usb_basic/src/HW/comm
    r_usb_basic/src/HW/comm/: r_usb_creg_abs.c r_usb_creg_access.c r_usb_creg_dmadtc.c rx_mcu.c
  group FIT Modules/r_usb_basic/src/HW/host
    r_usb_basic/src/HW/host/: r_usb_hostelectrical.c r_usb_hreg_abs.c r_usb_hreg_access.c
  group FIT Modules/r_usb_basic/src/HW/inc
    r_usb_basic/src/HW/inc/: r_usb_cusb_bitdefine.h r_usb_defvalue.h r_usb_fixed_config.h r_usb_reg_access.h r_usb_sysdef.h rx_rsk_extern.h
  group FIT Modules/r_usb_basic/src/HW/peri
    r_usb_basic/src/HW/peri/: r_usb_preg_abs.c r_usb_preg_access.c
  group FIT Modules/r_usb_pmsc
    r_usb_pmsc/: r_media_driver_if.h r_usb_pmsc_if.h readme.txt
  group FIT Modules/r_usb_pmsc/doc
    r_usb_pmsc/doc/: r01an2029ej0111_usb.pdf
  group FIT Modules/r_usb_pmsc/ref
    r_usb_pmsc/ref/: r_media_driver_api_config_reference.h r_usb_atapi_driver_config_reference.h r_usb_pmsc_config_reference.h
  group FIT Modules/r_usb_pmsc/src
    r_usb_pmsc/src/: r_media_driver_api.c r_usb_atapi_driver.c r_usb_pmsc_api.c r_usb_pmsc_ddi.c r_usb_pmsc_driver.c r_usb_pmsc_pci.c
  group FIT Modules/r_usb_pmsc/src/inc
    r_usb_pmsc/src/inc/: r_usb_patapi_define.h r_usb_pmsc_api.h r_usb_pmsc_define.h r_usb_pmsc_extern.h
  group r_bsp
    r_bsp/: platform.h readme.txt
  group r_bsp/board/rpbrx71m
    r_bsp/board/rpbrx71m/: hwsetup.c hwsetup.h r_bsp.h r_bsp_config_reference.h r_bsp_interrupt_config_reference.h resetprg.c rpbrx71m.h vecttbl.c vecttbl.h
  group r_bsp/doc
    r_bsp/doc/: r01an1685ej0330_rx.pdf
  group r_bsp/mcu/all
    r_bsp/mcu/all/: r_bsp_common.c r_bsp_common.h r_typedefs.h
  group r_bsp/mcu/rx71m
    r_bsp/mcu/rx71m/: cpu.c cpu.h locking.c locking.h mcu_clocks.c mcu_info.h mcu_init.c mcu_init.h mcu_interrupts.c mcu_interrupts.h mcu_locks.c mcu_locks.h mcu_mapped_interrupts.c mcu_mapped_interrupts.h mcu_mapped_interrupts_private.h
  group r_bsp/mcu/rx71m/register_access
    r_bsp/mcu/rx71m/register_access/: iodefine.h
  group r_config
    r_config/: r_bsp_config.h r_bsp_interrupt_config.h r_flash_rx_config.h r_media_driver_api_config.h r_tfat_rx_config.h r_usb_atapi_driver_config.h r_usb_basic_config.h r_usb_pmsc_config.h readme.txt
  group r_Packages/config
    r_Packages/config/: config_r_ddlcd.h config_r_ddlcd_panel.h config_r_ddlcd_platform.h config_r_freertos.h config_r_gapi.h config_r_packages.h freertosconfig.h
  group r_Packages/r_ddlcd
    r_Packages/r_ddlcd/: r_ddlcd_dispmemory.h r_ddlcd_public.h
  group r_Packages/r_ddlcd/src
    r_Packages/r_ddlcd/src/: r_ddlcd.c r_ddlcd_dispmemory.c r_ddlcd_frames.c r_ddlcd_private.h
  group r_Packages/r_freertos
    r_Packages/r_freertos/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h portmacro.h projdefs.h queue.h r_FreeRTOS.h semphr.h StackMacros.h task.h timers.h
  group r_Packages/r_freertos/src
    r_Packages/r_freertos/src/: croutine.c list.c queue.c readme.txt tasks.c timers.c
  group r_Packages/r_freertos/src/include
    r_Packages/r_freertos/src/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group r_Packages/r_freertos/src/portable
    r_Packages/r_freertos/src/portable/: readme.txt
  group r_Packages/r_freertos/src/portable/GCC/RX600
    r_Packages/r_freertos/src/portable/GCC/RX600/: port.c portmacro.h
  group r_Packages/r_freertos/src/portable/IAR/RX600
    r_Packages/r_freertos/src/portable/IAR/RX600/: port.c port_asm.s portmacro.h
  group r_Packages/r_freertos/src/portable/MemMang
    r_Packages/r_freertos/src/portable/MemMang/: heap_1.c heap_2.c heap_3.c
  group r_Packages/r_freertos/src/portable/Renesas/H8S_H8SX
    r_Packages/r_freertos/src/portable/Renesas/H8S_H8SX/: heap_3.c port.c portmacro.h Readme.txt
  group r_Packages/r_freertos/src/portable/Renesas/RX200
    r_Packages/r_freertos/src/portable/Renesas/RX200/: port.c portmacro.h
  group r_Packages/r_freertos/src/portable/Renesas/RX600
    r_Packages/r_freertos/src/portable/Renesas/RX600/: port.c portmacro.h
  group r_Packages/r_gapi
    r_Packages/r_gapi/: r_gapic_core.h r_gapiu_utility.h r_gapiw_wrapper.h
  group r_Packages/r_gapi/src
    r_Packages/r_gapi/src/: r_gapi_private.h r_gapi_public.h r_gapic_copy.c r_gapic_font.c r_gapic_font.h r_gapic_gradient.c r_gapic_xlate.c r_gapiu_bmp.c r_gapiu_memory.c r_gapiw_button.c r_gapiw_scroll.c

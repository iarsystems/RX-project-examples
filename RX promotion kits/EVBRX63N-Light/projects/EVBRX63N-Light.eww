<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LED\LED.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\RTC_Alarm\RTC_Alarm.ewp</path>
  </project>
  <batchBuild/>
</workspace>



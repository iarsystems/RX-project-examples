# IAR project USB_PMSC.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F51115 R5F51115
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: __RX
  ICCRX.CCDiagSuppress: Pe177
  ICCRX.CCIncludePath2: src/HwResource/inc; src/media_driver; src/media_driver/ramdisk; src/MSCFW/inc; src/MSCFW/MEDIA; src/MSCFW/PMSC; src/USBSTDFW/inc
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Description.txt
  group HwResource/src
    src/HwResource/src/: hwsetup.c leddriver_rx111.c resetprg.c rx111usbmcu.c
  group media_driver
    src/media_driver/: r_media_driver_api.c
  group media_driver/ramdisk
    src/media_driver/ramdisk/: r_ram_disk.c r_ram_disk_format_data.c
  group MSCFW/MEDIA
    src/MSCFW/MEDIA/: r_usb_atapi_driver.c
  group MSCFW/PMSC
    src/MSCFW/PMSC/: r_usb_pmsc_api.c r_usb_pmsc_ddi.c r_usb_pmsc_driver.c r_usb_pmsc_pci.c r_usb_pmsc_request.c
  group SmplMain
    src/SmplMain/: main.c
  group SmplMain/APL
    src/SmplMain/APL/: r_usb_pmsc_apl.c r_usb_pmsc_descriptor.c
  group USBSTDFW/src
    src/USBSTDFW/src/: r_usb_cstdapi.c r_usb_cstdfunction.c r_usb_pbc.c r_usb_pdriver.c r_usb_pdriverapi.c

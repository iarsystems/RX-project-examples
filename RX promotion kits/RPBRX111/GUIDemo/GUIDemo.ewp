# IAR project GUIDemo.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F51115 R5F51115
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: __RX; _SYS_INT_TYPES_H
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group cg_src
    cg_src/: r_cg_cgc.c r_cg_cgc.h r_cg_cgc_user.c r_cg_icu.c r_cg_icu.h r_cg_icu_user.c r_cg_intprg.c r_cg_lpc.c r_cg_lpc.h r_cg_lpc_user.c r_cg_macrodriver.h r_cg_main.c r_cg_port.c r_cg_port.h r_cg_port_user.c r_cg_rtc.c r_cg_rtc.h r_cg_rtc_user.c r_cg_systeminit.c r_cg_userdefine.h
  group user_src
    cg_src/: bootflags.c commands.c lowlvl_debug_console.c

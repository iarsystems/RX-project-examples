# IAR project LowPowerFileCopy.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F51115 R5F51115
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: __RX; __LIT; USB_FUNCSEL_PP=USB_HOST_PP; USB_PORTSEL_PP=USB_1PORT_PP; USB_TFAT_USE_PP
  ICCRX.CCIncludePath2: src/HwResourceForUSB/inc; src/USBSTDFW/inc; src/HMSC/inc; src/HMSC/TFAT/lib_src
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: lnkr5f51115.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Description.txt
  group HMSC/src
    src/HMSC/src/: r_usb_hmsc_api.c r_usb_hmsc_ddi.c r_usb_hmsc_driver.c r_usb_hmsc_fsi.c r_usb_hmsc_hci.c r_usb_hstorage_driver.c
  group HMSC/TFAT/lib
    src/HMSC/TFAT/lib/: tfat_rx600_little.a
  group HMSC/TFAT/lib_src
    src/HMSC/TFAT/lib_src/: r_tfat_drv_if.c
  group HwResourceForUSB/src
    src/HwResourceForUSB/src/: ascii.c hwsetup.c keydriver_rx111.c lcd.c lcddriver_rx111.c leddriver_rx111.c r_cg_sci.c r_cg_sci_user.c resetprg.c rx111usbmcu.c
  group SmplMain
    src/SmplMain/: main.c
  group SmplMain/APL
    src/SmplMain/APL/: r_usb_hmsc_apl.c r_usb_hmsc_datafile.c
  group USBSTDFW/src
    src/USBSTDFW/src/: r_usb_cstdapi.c r_usb_cstdfunction.c r_usb_h1port.c r_usb_h2port.c r_usb_hbc.c r_usb_hdriver.c r_usb_hdriverapi.c r_usb_hp0function.c r_usb_hp1function.c

# IAR project USB_LibUSB.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F51115 R5F51115
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: __RX; __LIT; USB_KEY_ENABLE
  ICCRX.CCDiagSuppress: Pe111,Pe177
  ICCRX.CCIncludePath2: src/HwResourceForUSB/inc; src/HwResourceForUSB/src; src/USBSTDFW/inc; src/VENDOR/inc; src/RX111_ADC; src/RX111_ADC/r_s12ad_rx; src/RX111_ADC/r_s12ad_rx/src; src/RX111_ADC/r_bsp; src/RX111_ADC/r_config
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Description.txt
  group HwResourceForUSB/src
    src/HwResourceForUSB/src/: ascii.c hwsetup.c keydriver_rx111.c lcd.c lcddriver_rx111.c leddriver_rx111.c r_cg_sci.c r_cg_sci_user.c resetprg.c rx_mcu.c
  group RX111_ADC/r_bsp/mcu/rx111
    src/RX111_ADC/r_bsp/mcu/rx111/: locking.c mcu_locks.c
  group RX111_ADC/r_s12ad_rx/src
    src/RX111_ADC/r_s12ad_rx/src/: r_s12ad_rx.c
  group SmplMain
    src/SmplMain/: main.c
  group SmplMain/APL
    src/SmplMain/APL/: r_usb_vendor_descriptor.c r_usb_vendor_papl.c
  group USBSTDFW/src
    src/USBSTDFW/src/: r_usb_cstdapi.c r_usb_cstdfunction.c r_usb_pbc.c r_usb_pdriver.c r_usb_pdriverapi.c
  group VENDOR/src
    src/VENDOR/src/: r_usb_vendor_papi.c r_usb_vendor_pdriver.c

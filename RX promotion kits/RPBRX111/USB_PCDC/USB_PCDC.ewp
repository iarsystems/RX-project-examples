# IAR project USB_PCDC.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F51115 R5F51115
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: __RX; RX111USB
  ICCRX.CCDiagSuppress: Pe177
  ICCRX.CCIncludePath2: src/HwResourceForUSB/inc; src/PCDC/inc; src/USBSTDFW/inc
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Description.txt
  group HwResourceForUSB/src
    src/HwResourceForUSB/src/: ascii.c hwsetup.c keydriver_rx111.c lcd.c lcddriver_rx111.c leddriver_rx111.c r_cg_sci.c r_cg_sci_user.c resetprg.c rx111usbmcu.c
  group PCDC/src
    src/PCDC/src/: r_usb_pcdc_api.c r_usb_pcdc_driver.c
  group SmplMain
    src/SmplMain/: main.c
  group SmplMain/APL
    src/SmplMain/APL/: r_usb_echo_apl.c r_usb_echo_apl_descriptor.c
  group USBSTDFW/src
    src/USBSTDFW/src/: r_usb_cstdapi.c r_usb_cstdfunction.c r_usb_hport.h r_usb_pbc.c r_usb_pdriver.c r_usb_pdriverapi.c

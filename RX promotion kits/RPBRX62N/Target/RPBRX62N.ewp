# IAR project RPBRX62N.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F562N8 R5F562N8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x200
  General.IStackSize: 0x1000
  General.HeapSize: 0x1000
  ICCRX.CCDiagSuppress: Pa082,Pe111
  ICCRX.CCIncludePath2: RPDL/; inc; i2c; ball; pong; Sample; App; mt; USBStack; USBStack/HID; uip_app/mandelbrot; uip/uip; uip/unix; uip/apps/webserver; uip/apps/dhcpc; uip_app/vnc
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$/inc/
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: RPDL/rx62n_library.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    Sample/: async.c cstartup.s hwsetup.c lcd.c main.c switch.c
  group ball
    ball/: Ball.c ball_demo.c Ball_FPU.c ball_var.c screen_var.c
  group i2cprom
    i2c/: i2cprom.c
  group mtarch
    mt/: mt.c mtarch.c
  group pong
    pong/: pong.c pong_ball.c pong_paddles.c pong_scores.c pong_var.c
  group RPDL
    RPDL/: Interrupt_ADC_10.c Interrupt_BSC.c Interrupt_CMT.c Interrupt_DMAC.c Interrupt_IIC.c Interrupt_INTC.c Interrupt_not_RPDL.c Interrupt_SCI.c Interrupt_TMR.c Interrupt_WDT.c
  group uip/apps
    uip/apps/: allapps.c
  group uip/apps/dhpc
    uip/apps/dhcpc/: dhcpc.c
  group uip/apps/vnc
    uip_app/vnc/: vnc-out.c vnc-server.c
  group uip/apps/webserver
    uip/apps/webserver/: http-strings.c httpd-cgi.c httpd-fs.c httpd.c
  group uip/uip
    uip/uip/: psock.c timer.c uip-fw.c uip-neighbor.c uip-split.c uip.c uip_arp.c uiplib.c
  group uip/unix
    uip/unix/: clock-arch.c
  group uip_app
    uip_app/: uip_app.c uip_main.c
  group uip_app/driver
    uip_app/driver/: hwEthernet.c hwEthernetPhy.c
  group uip_app/drystone
    uip_app/dhrystone/: dhry_1.c dhry_2.c
  group uip_app/mandelbrot
    uip_app/mandelbrot/: mandel.c
  group USB
    USBStack/: usb_core.c usb_hal.c
    USBStack/HID/: usb_hid.c usbdescriptors.c
    App/: usb_hid_app.c

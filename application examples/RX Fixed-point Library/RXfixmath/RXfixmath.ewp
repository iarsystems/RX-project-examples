# IAR project RXfixmath.ewp, settings and files
configuration Debug_little (RX, debug)
  General.OGChipSelectMenu: R5F51114 R5F51114
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCIncludePath2: inc
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_big (RX, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: R5F51115 R5F51115
  group lib
    lib/: RXfixmath_big.a RXfixmath_little.a
  group src
    src/: main.c

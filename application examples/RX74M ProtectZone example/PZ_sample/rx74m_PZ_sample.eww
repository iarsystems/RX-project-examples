<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\rx74m_ns\rx74m_ns.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\rx74m_sec\rx74m_sec.ewp</path>
    </project>
    <batchBuild />
</workspace>

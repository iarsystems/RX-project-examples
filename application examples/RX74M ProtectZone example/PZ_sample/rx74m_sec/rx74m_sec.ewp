# IAR project rx74m_sec.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5K574MC R5K574MC
  General.GenCodeModel: 0
  General.GenDataModel: 2
  General.StackSize: 0x800
  General.IStackSize: 0x800
  General.HeapSize: 0x800
  ICCRX.CCDefines: _RX_PZ_SECURE=1; BSP_FEATURE_PZ_S_OFFSET=0x80000000
  ICCRX.CCIncludePath2: generate
  ICCRX.IccExtraOptions: --protect_zone
  ICCRX.IccLang: 0
  OBJCOPY.OOCOutputFile: rx74m_sec.srec
  ILINK.IlinkOutputFile: rx74m_sec.out
  ILINK.IlinkIcfFile: lnkr5k574mc-sec.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: cstartup_sec.s
    src/: hal_entry.c main_sec.c pz_cmn_func.c pz_sub_root.c r_irq.c r_irq.h r_pz.c r_pz.h
    generate/: hwinit.c interrupt_handlers.h inthandler.c iodefine.h R5K574M.h vects.c

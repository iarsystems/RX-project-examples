# IAR project FL_UserApp_RSKRX63N.ewp, settings and files
configuration Release (RX)
  General.OGChipSelectMenu: R5F563NB R5F563NB
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: NDEBUG; RSKRX63N
  ICCRX.CCDiagSuppress: Pe1665,Pe167
  ICCRX.CCIncludePath2: ..\r_bsp; ..\r_flash_loader_rx; ..\r_flash_loader_rx\src; ..\r_sci_async_1ch_rx; ..\r_sci_async_1ch_rx\src; ..\r_rspi_rx; ..\r_rspi_rx\src; ..\r_spi_flash; ..\r_spi_flash\src; ..\r_crc_rx; ..\r_crc_rx\src; ..\r_cmt_rx; ..\r_cmt_rx\src; $PROJ_DIR$; r_config
  ICCRX.IccLang: 0
  OBJCOPY.OOCOutputFile: FL_UserApp_RSKRX63N.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: lnkr5f563nb_FL_UserApp_RSKRX63N.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (RX, debug)
  as the first configuration, except:
  ICCRX.CCDefines: RSKRX63N
  ILINK.IlinkExtraOptions: --place_holder _checksum,2,.checksum,4
  group C source file
    ../src/: flash_loader_user_app_main.c
  group C source file/BSP
    ../r_bsp/board/rskrx63n/: hwsetup.c low_level_init.c sbrk.c
    ../r_bsp/mcu/rx63n/: locking.c mcu_locks.c
  group C source file/CRC
    ../r_crc_rx/src/: r_crc_rx.c
  group C source file/Flash_Loader
    ../r_flash_loader_rx/src/: r_fl_app_header.c r_fl_downloader.c r_fl_store_manager.c r_fl_utilities.c
    ../r_flash_loader_rx/src/communications/: r_fl_comm_uart.c
    ../r_flash_loader_rx/src/memory/: r_fl_memory_spi_flash.c
  group C source file/LCD
    ./: lcd.c
  group C source file/SCI_Async
    ../r_sci_async_1ch_rx/src/: r_sci_async_1ch_rx.c
  group C source file/SPI
    ../r_rspi_rx/src/: r_rspi_rx.c
    ../r_spi_flash/src/: r_spi_flash.c
  group C source file/Timer
    ../r_cmt_rx/src/: r_cmt_rx.c
  group FL_Batch_Files
    ./: fl_script_erase_b0.bat fl_script_erase_b1.bat fl_script_info.bat fl_script_load.bat
    ../r_flash_loader_rx/utilities/batch_files/: open_cmd_window.bat

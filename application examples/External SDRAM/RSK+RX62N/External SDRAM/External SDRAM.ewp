# IAR project External SDRAM.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F562N8 R5F562N8
  General.GenCodeModel: 0
  General.GenDataModel: 2
  General.StackSize: 0x100
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: __BOARD_VIBCOM_PROTOTYPE__
  ICCRX.CCDiagSuppress: Be006
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$/inc/
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: lnkr5f562n8_sdram.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkExtraOptions: --redirect __interrupt_1=_TestMe
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: bsp.c low_level_init.c main.c

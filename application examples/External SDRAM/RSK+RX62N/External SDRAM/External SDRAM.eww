<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\External SDRAM.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>test</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



# IAR project USB_Basic.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F51115 R5F51115
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: __RX; USB_FUNCSEL_PP=USB_PERI_PP
  ICCRX.CCIncludePath2: src/HwResourceForUSB/inc; src/USBSTDFW/inc; src/VENDOR/inc
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Description.txt
  group HwResrouceForUSB/src
    src/HwResourceForUSB/src/: ascii.c keydriver_rx111.c lcd.c lcddriver_rx111.c leddriver_rx111.c r_cg_sci.c r_cg_sci_user.c resetprg.c rx111usbmcu.c
  group SmplMain
    src/SmplMain/: main.c
  group SmplMain/APL
    src/SmplMain/APL/: r_usb_vendor_descriptor.c r_usb_vendor_hapl.c r_usb_vendor_papl.c
  group USBSTDFW/src
    src/USBSTDFW/src/: r_usb_cstdapi.c r_usb_cstdfunction.c r_usb_h1port.c r_usb_h2port.c r_usb_hbc.c r_usb_hdriver.c r_usb_hdriverapi.c r_usb_hp0function.c r_usb_hp1function.c r_usb_pbc.c r_usb_pdriver.c r_usb_pdriverapi.c
  group VENDOR/src
    src/VENDOR/src/: r_usb_vendor_hapi.c r_usb_vendor_hdriver.c r_usb_vendor_papi.c r_usb_vendor_pdriver.c

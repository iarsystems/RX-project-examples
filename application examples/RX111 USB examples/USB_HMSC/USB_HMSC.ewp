# IAR project USB_HMSC.ewp, settings and files
configuration Little Endian (RX, debug)
  General.OGChipSelectMenu: R5F51115 R5F51115
  General.GenCodeModel: 0
  General.GenDataModel: 2
  General.StackSize: 0x100
  General.IStackSize: 0x300
  General.HeapSize: 0x400
  ICCRX.CCDefines: __RX; __LIT; USB_TFAT_USE_PP
  ICCRX.CCIncludePath2: src/HMSC/inc; src/HMSC/TFAT/lib_src; src/HwResourceForUSB/inc; src/USBSTDFW/inc
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Description.txt
  group HMSC/src
    src/HMSC/src/: r_usb_hmsc_api.c r_usb_hmsc_ddi.c r_usb_hmsc_driver.c r_usb_hmsc_fsi.c r_usb_hmsc_hci.c r_usb_hstorage_driver.c
  group HMSC/TFAT/lib
    src/HMSC/TFAT/lib/: r_TinyFAT_little.a
  group HMSC/TFAT/lib_src
    src/HMSC/TFAT/lib_src/: r_tfat_drv_if.c
  group HwResourceForUSB/src
    src/HwResourceForUSB/src/: ascii.c ascii.h keydriver_rx111.c lcd.c lcddriver_rx111.c leddriver_rx111.c r_cg_macrodriver.h r_cg_sci.c r_cg_sci.h r_cg_sci_user.c r_cg_userdefine.h resetprg.c rx111usbmcu.c
  group SmplMain
    src/SmplMain/: main.c
  group SmplMain/APL
    src/SmplMain/APL/: r_usb_hmsc_apl.c
  group USBSTDFW/src
    src/USBSTDFW/src/: r_usb_cstdapi.c r_usb_cstdfunction.c r_usb_h1port.c r_usb_h2port.c r_usb_hbc.c r_usb_hdriver.c r_usb_hdriverapi.c r_usb_hp0function.c r_usb_hp1function.c

# IAR project FlashMemoryProtection.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F563NA R5F563NA
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.StackSize: 0x100
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  group (top)
    ./: main.c

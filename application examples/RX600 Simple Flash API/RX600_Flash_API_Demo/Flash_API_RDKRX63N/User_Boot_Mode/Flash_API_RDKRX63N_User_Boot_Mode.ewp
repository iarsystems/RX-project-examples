# IAR project Flash_API_RDKRX63N_User_Boot_Mode.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F563NB R5F563NB
  General.GenCodeModel: 0
  General.GenDataModel: 2
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: PLATFORM_BOARD_RDKRX63N; USER_BOOT_MODE
  ICCRX.CCIncludePath2: ..\..\r_flash_api_rx600\; ..\..\r_bsp\
  ICCRX.IccLang: 0
  OBJCOPY.OOCOutputFile: Flash_API_RDKRX63N_User_Boot_Mode.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: lnkr5f563nb_Flash_API_User_Boot.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../r_flash_api_rx600/src/: flash_api_rx600_demo_main.c r_flash_api_rx600.c
    ../../r_bsp/board/rdkrx63n/: hwsetup.c low_level_init.c
    ./: nmivec.s userbootvec.s

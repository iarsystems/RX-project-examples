# IAR project Flash_API_RSKRX63N.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F563NB R5F563NB
  General.GenCodeModel: 0
  General.GenDataModel: 2
  General.StackSize: 0x100
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: PLATFORM_BOARD_RSKRX63N
  ICCRX.CCIncludePath2: ..\r_flash_api_rx600\; ..\r_bsp\
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\
  OBJCOPY.OOCOutputFile: Flash_API_RSKRX63N.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: lnkr5f563nb_Flash_API.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../r_flash_api_rx600/src/: flash_api_rx600_demo_main.c r_flash_api_rx600.c
    ../r_bsp/board/rskrx63n/: hwsetup.c low_level_init.c

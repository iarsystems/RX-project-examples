# IAR project Flash_API_RSKRX62T.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F562TA R5F562TA
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x100
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: PLATFORM_BOARD_RSKRX62T
  ICCRX.CCIncludePath2: ../r_flash_api_rx600/; ../r_bsp/
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$/inc/
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: lnkr5f562ta_Flash_API.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../r_flash_api_rx600/src/: flash_api_rx600_demo_main.c r_flash_api_rx600.c
    ../r_bsp/board/rskrx62t/: hwsetup.c low_level_init.c

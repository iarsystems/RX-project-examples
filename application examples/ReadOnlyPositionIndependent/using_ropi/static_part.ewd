<?xml version="1.0" encoding="UTF-8"?>
<project>
    <fileVersion>6</fileVersion>
    <configuration>
        <name>Debug</name>
        <toolchain>
            <name>RX</name>
        </toolchain>
        <debug>1</debug>
        <settings>
            <name>CONFIGFILEDEBUG</name>
            <archiveVersion>0</archiveVersion>
            <data>
                <enabled>0</enabled>
                <debugConfigName></debugConfigName>
                <debugConfigFile></debugConfigFile>
            </data>
        </settings>
        <settings>
            <name>C-SPY</name>
            <archiveVersion>7</archiveVersion>
            <data>
                <version>9</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>CMandatory</name>
                    <state>1</state>
                </option>
                <option>
                    <name>CInput</name>
                    <state>1</state>
                </option>
                <option>
                    <name>DebuggerProcessorVariant</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CRunToEnable</name>
                    <state>1</state>
                </option>
                <option>
                    <name>CRunToName</name>
                    <state>main</state>
                </option>
                <option>
                    <name>CMacOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CMacFile</name>
                    <state></state>
                </option>
                <option>
                    <name>DynDriver</name>
                    <state>SIMRX</state>
                </option>
                <option>
                    <name>DDFOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DDFFile</name>
                    <state>$TOOLKIT_DIR$/config/debugger/ior5f56104.ddf</state>
                </option>
                <option>
                    <name>DebuggerUseExtraOptions</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebuggerExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>ODebuggerByteOrder</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODebuggerDoubleSize</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCImagesSuppressCheck1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesPath1</name>
                    <state>$PROJ_DIR$/Debug/Exe/ropi_image.out</state>
                </option>
                <option>
                    <name>OCImagesSuppressCheck2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesPath2</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesSuppressCheck3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesPath3</name>
                    <state></state>
                </option>
                <option>
                    <name>ODebuggerCore</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODebuggerIntSize</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCImagesOffset1</name>
                    <state>0x10000</state>
                </option>
                <option>
                    <name>OCImagesOffset2</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesOffset3</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesUse1</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCImagesUse2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesUse3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODebuggerPatch</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODebuggerFpu</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODebuggerSuppressEntrypointWarning</name>
                    <state>0</state>
                </option>
                <option>
                    <name>Debugger</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCRuntimeLibrary</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>RXE2</name>
            <archiveVersion>4</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E2Mandatory</name>
                    <state>1</state>
                </option>
                <option>
                    <name>E2DownloadSuppressDownload</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2DownloadVerifyAll</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2DownloadOnlyChangedBlocks</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LogFile</name>
                    <state>$PROJ_DIR$/cspycomm.log</state>
                </option>
                <option>
                    <name>E2DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2DebuggingModeList</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwPinMode</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwRegMode</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwCpuEndianSlave</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwStartupBank</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwUseExtal</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtalOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtal</name>
                    <state></state>
                </option>
                <option>
                    <name>HwAllowClockSourceChange</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwWorkRamOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwWorkRamStart</name>
                    <state></state>
                </option>
                <option>
                    <name>HwInterface</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwJtagClock</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwFineBaudRate</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwProgramRewrite</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwDataFlashRewrite</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwEraseFlash</name>
                    <state>1</state>
                </option>
                <option>
                    <name>HwEraseDataFlash</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS0ByteOrder</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS0Width</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS1ByteOrder</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS1Width</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS2ByteOrder</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS2Width</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS3ByteOrder</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS3Width</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS4ByteOrder</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS4Width</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS5ByteOrder</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS5Width</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS6ByteOrder</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS6Width</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS7ByteOrder</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS7Width</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaSDCSByteOrder</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaSDCSWidth</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwIclkOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwIclk</name>
                    <state></state>
                </option>
                <option>
                    <name>HwIdCode</name>
                    <state>FFFFFFFFFFFFFFFFFFFFFFFFFFFFFFFF</state>
                </option>
                <option>
                    <name>HwPowerSupply</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtFlash0Use</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtFlash0File</name>
                    <state></state>
                </option>
                <option>
                    <name>HwExtFlash0Erase</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtFlash1Use</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtFlash1File</name>
                    <state></state>
                </option>
                <option>
                    <name>HwExtFlash1Erase</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtFlash2Use</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtFlash2File</name>
                    <state></state>
                </option>
                <option>
                    <name>HwExtFlash2Erase</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtFlash3Use</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtFlash3File</name>
                    <state></state>
                </option>
                <option>
                    <name>HwExtFlash3Erase</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2UseEmuSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2EmuSerialNo</name>
                    <state></state>
                </option>
            </data>
        </settings>
        <settings>
            <name>RXE2LITE</name>
            <archiveVersion>4</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E2LiteMandatory</name>
                    <state>1</state>
                </option>
                <option>
                    <name>E2LiteDownloadSuppressDownload</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteDownloadVerifyAll</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteDownloadOnlyChangedBlocks</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteLogFile</name>
                    <state>$PROJ_DIR$/cspycomm.log</state>
                </option>
                <option>
                    <name>E2LiteDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteDebuggingModeList</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwPinMode</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwRegMode</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwCpuEndianSlave</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwStartupBank</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwUseExtal</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtalOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtal</name>
                    <state></state>
                </option>
                <option>
                    <name>HwAllowClockSourceChange</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwWorkRamOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwWorkRamStart</name>
                    <state></state>
                </option>
                <option>
                    <name>HwInterface</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwJtagClock</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwFineBaudRate</name>
                    <version>0</version>
                    <state>1</state>
                </option>
                <option>
                    <name>HwProgramRewrite</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwDataFlashRewrite</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwEraseFlash</name>
                    <state>1</state>
                </option>
                <option>
                    <name>HwEraseDataFlash</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS0ByteOrder</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS0Width</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS1ByteOrder</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS1Width</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS2ByteOrder</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS2Width</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS3ByteOrder</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS3Width</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS4ByteOrder</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS4Width</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS5ByteOrder</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS5Width</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS6ByteOrder</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS6Width</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS7ByteOrder</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS7Width</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaSDCSByteOrder</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaSDCSWidth</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwIclkOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwIclk</name>
                    <state></state>
                </option>
                <option>
                    <name>HwIdCode</name>
                    <state>FFFFFFFFFFFFFFFFFFFFFFFFFFFFFFFF</state>
                </option>
                <option>
                    <name>HwPowerSupply</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtFlash0Use</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtFlash0File</name>
                    <state></state>
                </option>
                <option>
                    <name>HwExtFlash0Erase</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtFlash1Use</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtFlash1File</name>
                    <state></state>
                </option>
                <option>
                    <name>HwExtFlash1Erase</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtFlash2Use</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtFlash2File</name>
                    <state></state>
                </option>
                <option>
                    <name>HwExtFlash2Erase</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtFlash3Use</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtFlash3File</name>
                    <state></state>
                </option>
                <option>
                    <name>HwExtFlash3Erase</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteUseEmuSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteEmuSerialNo</name>
                    <state></state>
                </option>
            </data>
        </settings>
        <settings>
            <name>RXJLINK</name>
            <archiveVersion>5</archiveVersion>
            <data>
                <version>7</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>JlinkMandatory</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCJlinkDownloadSuppressDownload</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCJlinkDownloadVerifyAll</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCJlinkScanChainEnable</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCJlinkDevicePosition</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCJlinkOtherDeviceTypes</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCJlinkPreceedingIRBits</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCJlinkUseUSBSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCJlinkUSBSerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>JLinkLogFile</name>
                    <state>$PROJ_DIR$/cspycomm.log</state>
                </option>
                <option>
                    <name>JLinkDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCDebuggingModeList</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwPinMode</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwRegMode</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwCpuEndianSlave</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwStartupBank</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwUseExtal</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtalOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtal</name>
                    <state></state>
                </option>
                <option>
                    <name>HwAllowClockSourceChange</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwWorkRamOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwWorkRamStart</name>
                    <state></state>
                </option>
                <option>
                    <name>HwInterface</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwJtagClock</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwFineBaudRate</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwProgramRewrite</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwDataFlashRewrite</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwEraseFlash</name>
                    <state>1</state>
                </option>
                <option>
                    <name>HwEraseDataFlash</name>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS0ByteOrder</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS0Width</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS1ByteOrder</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS1Width</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS2ByteOrder</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS2Width</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS3ByteOrder</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS3Width</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS4ByteOrder</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS4Width</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS5ByteOrder</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS5Width</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS6ByteOrder</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS6Width</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS7ByteOrder</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaCS7Width</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaSDCSByteOrder</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>HwExtAreaSDCSWidth</name>
                    <version>0</version>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>SIMRX</name>
            <archiveVersion>2</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>SimMandatory</name>
                    <state>1</state>
                </option>
                <option>
                    <name>SimHaveTfu</name>
                    <state>1</state>
                </option>
                <option>
                    <name>SimTfuVersion</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <debuggerPlugins>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\OpenRTOS\OpenRTOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\SafeRTOS\SafeRTOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\TargetAccessServer\TargetAccessServer.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\uCProbe\uCProbePlugin.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
        </debuggerPlugins>
    </configuration>
</project>

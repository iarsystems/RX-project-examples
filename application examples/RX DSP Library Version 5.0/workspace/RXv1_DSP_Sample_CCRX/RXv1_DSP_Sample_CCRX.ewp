# IAR project RXv1_DSP_Sample_CCRX.ewp, settings and files
configuration RXV1_DSP_FPU_LE_Check (RX, debug)
  General.OGChipSelectMenu: rx911 RXv1 Fpu32
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x400
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDiagSuppress: Pa050,Pe009,Pe301,Pa089
  ICCRX.CCIncludePath2: dsplib-rxv1
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RXV1_DSP_FPU_LE (RX, debug)
  as the first configuration, except:
configuration RXV1_DSP_FPU_BE_Check (RX, debug)
  as the first configuration, except:
configuration RXV1_DSP_FPU_BE (RX, debug)
  as the first configuration, except:
configuration RXV1_DSP_NOFPU_LE_Check (RX, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: rx910 RXv1 NoFpu
configuration RXV1_DSP_NOFPU_LE (RX, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: rx910 RXv1 NoFpu
configuration RXV1_DSP_NOFPU_BE_Check (RX, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: rx910 RXv1 NoFpu
configuration RXV1_DSP_NOFPU_BE (RX, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: rx910 RXv1 NoFpu
  group dsplib-rxv1
    dsplib-rxv1/: r_dsp_complex.h r_dsp_filters.h r_dsp_matrix.h r_dsp_statistical.h r_dsp_transform.h r_dsp_typedefs.h r_dsp_types.h r_dsp_ver_info.h RX_DSP_FPU_BE.lib RX_DSP_FPU_BE_Check.lib RX_DSP_FPU_LE.lib RX_DSP_FPU_LE_Check.lib RX_DSP_NOFPU_BE.lib RX_DSP_NOFPU_BE_Check.lib RX_DSP_NOFPU_LE.lib RX_DSP_NOFPU_LE_Check.lib
  group generate
    generate/: hwsetup.c iodefine.h resetprg.c typedefine.h
  group src
    src/: cFFT_in64_i16.h rFFT_in256_f32.h sample_dsp_complexFFT.c sample_dsp_fir.c sample_dsp_iirbiquad.c sample_dsp_iirsinglepole.c sample_dsp_main.c sample_dsp_main.h sample_dsp_realFFT.c windowCoefficient_f32.h

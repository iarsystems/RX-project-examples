<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\RXv3_DSP_Sample_CCRX.ewp</path>
  </project>
  <batchBuild/>
</workspace>

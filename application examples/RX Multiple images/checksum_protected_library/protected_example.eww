<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\application\application.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\library\protected_lib.ewp</path>
  </project>
  <batchBuild/>
</workspace>



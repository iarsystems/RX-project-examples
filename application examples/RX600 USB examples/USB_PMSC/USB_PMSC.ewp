# IAR project USB_PMSC.ewp, settings and files
configuration RX62N (RX, debug)
  General.OGChipSelectMenu: R5F562N8 R5F562N8
  General.GenCodeModel: 0
  General.GenDataModel: 2
  General.StackSize: 0x0
  General.IStackSize: 0x1000
  General.HeapSize: 0x400
  ICCRX.CCDefines: USB_FW_PP=USB_FW_NONOS_PP
  ICCRX.CCDiagSuppress: Pe009
  ICCRX.CCIncludePath2: ANSI; HwResourceForUSB_RX62N; media_driver; media_driver/ram_disk; MSCFW; MSCFW/MEDIA; USBSTDFW
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: lnkr5f562n8_sdram.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RX63N (RX, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: R5F563NB R5F563NB
  ICCRX.CCIncludePath2: ANSI; HwResourceForUSB_RX63N; media_driver; media_driver/ram_disk; MSCFW; MSCFW/MEDIA; USBSTDFW
  group ANIS
    ANSI/: r_usb_ansi.c r_usb_ansi_peri.c r_usb_otherclass.c
  group HwResourceForUSB_RX62N
    HwResourceForUSB_RX62N/: adcdriver.c hwsetup.c keydriver.c lcddriver.c leddriver.c lowsrc.c r_usb_creg_abs.c r_usb_creg_access.c r_usb_creg_dmadtc.c r_usb_preg_abs.c r_usb_preg_access.c resetprg.c rx_mcu.c scidriver.c
  group HwResourceForUSB_RX63N
    HwResourceForUSB_RX63N/: adcdriver.c hwsetup.c keydriver.c lcddriver.c leddriver.c lowsrc.c r_usb_creg_abs.c r_usb_creg_access.c r_usb_creg_dmadtc.c r_usb_preg_abs.c r_usb_preg_access.c resetprg.c rx_mcu.c scidriver.c
  group media_driver
    media_driver/: r_media_driver_api.c
  group media_driver/ram_disk
    media_driver/ram_disk/: r_ram_disk.c r_ram_disk_format_data.c
  group MSCFW
    MSCFW/: r_usb_pmsc_ddi.c r_usb_pmsc_driver.c r_usb_pmsc_pci.c r_usb_pmsc_request.c
  group MSCFW/MEDIA
    MSCFW/MEDIA/: r_usb_atapi_driver.c
  group SmplMain
    SmplMain/: main.c r_usb_pmsc_apl.c r_usb_pmsc_descriptor.c
  group USBSTDFW/class/SMPL
    USBSTDFW/class/SMPL/: r_usb_smp_csub.c
  group USBSTDFW/USB20/LIB
    USBSTDFW/USB20/LIB/: r_usb_cdataio.c r_usb_cintfifo.c r_usb_cinthandler_usbip0.c r_usb_cinthandler_usbip1.c r_usb_clibusbip.c r_usb_cscheduler.c r_usb_cstdapi.c r_usb_cstdfunction.c
  group USBSTDFW/USB20/PCD
    USBSTDFW/USB20/PCD/: r_usb_pcontrolrw.c r_usb_pdriver.c r_usb_pdriverapi.c r_usb_pintfifo.c r_usb_psignal.c r_usb_pstdfunction.c r_usb_pstdrequest.c

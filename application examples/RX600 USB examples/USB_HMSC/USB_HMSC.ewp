# IAR project USB_HMSC.ewp, settings and files
configuration RX62N (RX, debug)
  General.OGChipSelectMenu: R5F562N8 R5F562N8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: USB_FW_PP=USB_FW_NONOS_PP; USB_TFAT_USE_PP=1
  ICCRX.CCDiagSuppress: Pe767,Pe549,Pe174
  ICCRX.CCIncludePath2: ANSI; HwResourceForUSB_RX62N; MSCFW; MSCFW\TFAT; USBSTDFW
  ICCRX.IccLang: 0
  OBJCOPY.OOCOutputFile: USB_HMSC.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: MSCFW\TFAT\lib\TFAT.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RX63N (RX, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: R5F563NB R5F563NB
  ICCRX.CCIncludePath2: ANSI; HwResourceForUSB_RX63N; MSCFW; MSCFW\TFAT; USBSTDFW
  group ANSI
    ANSI/: r_usb_ansi.c r_usb_ansi_host.c r_usb_otherclass.c
  group HwResourceForUSB_RX62N
    HwResourceForUSB_RX62N/: adcdriver.c hwsetup.c keydriver.c lcddriver.c leddriver.c lowsrc.c r_usb_creg_abs.c r_usb_creg_access.c r_usb_creg_dmadtc.c r_usb_hreg_abs.c r_usb_hreg_access.c resetprg.c rx_mcu.c scidriver.c
  group HwResourceForUSB_RX63N
    HwResourceForUSB_RX63N/: adcdriver.c hwsetup.c keydriver.c lcddriver.c leddriver.c lowsrc.c r_usb_creg_abs.c r_usb_creg_access.c r_usb_creg_dmadtc.c r_usb_hreg_abs.c r_usb_hreg_access.c resetprg.c rx_mcu.c scidriver.c
  group MSCFW
    MSCFW/: r_usb_hmsc_ansi.c r_usb_hmsc_api.c r_usb_hmsc_ddi.c r_usb_hmsc_driver.c r_usb_hmsc_fsi.c r_usb_hmsc_hci.c r_usb_hstorage_driver.c
  group MSCFW/TFAT
    MSCFW/TFAT/: r_tfat_drv_if.c
  group MSCFW/TFAT/lib
    MSCFW/TFAT/lib/: TFAT.a
  group SmplMain
    SmplMain/: main.c r_usb_hmsc_apl.c
  group USBSTDFW
    USBSTDFW/: r_usb_cdataio.c r_usb_cintfifo.c r_usb_cinthandler_usbip0.c r_usb_cinthandler_usbip1.c r_usb_clibusbip.c r_usb_cscheduler.c r_usb_cstdapi.c r_usb_cstdfunction.c r_usb_hcontrolrw.c r_usb_hdriver.c r_usb_hdriverapi.c r_usb_hhubsys.c r_usb_hintfifo.c r_usb_hlibusbip.c r_usb_hmanager.c r_usb_hsignal.c r_usb_hstdfunction.c r_usb_smp_csub.c r_usb_smp_hsub.c

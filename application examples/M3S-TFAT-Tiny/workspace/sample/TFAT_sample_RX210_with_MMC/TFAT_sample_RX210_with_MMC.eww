<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TFAT_sample_RX210_with_MMC.ewp</path>
  </project>
  <batchBuild/>
</workspace>



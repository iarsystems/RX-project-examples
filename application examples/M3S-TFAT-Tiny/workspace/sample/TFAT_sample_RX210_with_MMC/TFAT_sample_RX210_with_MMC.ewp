# IAR project TFAT_sample_RX210_with_MMC.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F52108B R5F52108B
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDiagSuppress: Pa082,Pe009
  ICCRX.CCIncludePath2: lib; ew_files; mmc_source\com; mmc_source\mmc; mmc_source\sample\rx210_rsk; mmc_source\com\rx200_50MHz; mmc_source\mmc\rx\rx210_rspi
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group C source file/ew_files
    ew_files/: excep_BRK.c hwsetup.c low_level_init.c
  group C source file/mmc_source/com
    mmc_source/com/: r_mtl_com.c r_mtl_endi.c r_mtl_mem.c r_mtl_str.c r_mtl_tim.c
  group C source file/mmc_source/mmc
    mmc_source/mmc/: r_mmc_io.c r_mmc_mmc.c r_mmc_sub.c r_mmc_usr.c
  group C source file/mmc_source/mmc/rx
    mmc_source/mmc/rx/: r_mmc_rspi.c r_mmc_sci.c
  group C source file/tfat_sample
    tfat_sample/: r_data_file.c r_main.c r_tfat_drv_if.c
  group Library file
    lib/: tfat_rx200_little.a

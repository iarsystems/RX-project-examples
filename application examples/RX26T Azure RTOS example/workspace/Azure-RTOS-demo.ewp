# IAR project Azure-RTOS-demo.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F526TF R5F526TF
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x800
  General.IStackSize: 0x800
  General.HeapSize: 0x800
  ICCRX.CCDefines: TX_INCLUDE_USER_DEFINE_FILE
  ICCRX.CCIncludePath2: src/smc_gen/general; src/smc_gen/r_bsp; src/smc_gen/r_cmt_rx; src/smc_gen/r_config; src/smc_gen/r_pincfg; libs/threadx/ports/rxv3/iar/inc; libs/threadx; libs/threadx/common/inc; libs/threadx/utility/low_power; src/rtos_config; src/smc_gen/r_cmt_rx/src
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: Azure-RTOS-demo.out
  ILINK.IlinkIcfFile: src/lnkr5f526tf.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: buildinfo.ipcf
  group Application_AP
    ./: README.md
  group Application_AP/src
    src/: demo_threadx.c hardware_setup.c hardware_setup.h lnkr5f526tf.icf
  group Renesas_AP/libs/threadx
    libs/threadx/: tx_user.h
  group Renesas_AP/libs/threadx/common
    libs/threadx/common/: CMakeLists.txt
  group Renesas_AP/libs/threadx/common/inc
    libs/threadx/common/inc/: tx_api.h tx_block_pool.h tx_byte_pool.h tx_event_flags.h tx_initialize.h tx_mutex.h tx_queue.h tx_semaphore.h tx_thread.h tx_timer.h tx_trace.h tx_user_sample.h
  group Renesas_AP/libs/threadx/common/src
    libs/threadx/common/src/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_performance_info_get.c tx_block_pool_performance_system_info_get.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_performance_info_get.c tx_byte_pool_performance_system_info_get.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_performance_info_get.c tx_event_flags_performance_system_info_get.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_misra.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_performance_info_get.c tx_mutex_performance_system_info_get.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_performance_info_get.c tx_queue_performance_system_info_get.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_performance_info_get.c tx_semaphore_performance_system_info_get.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_performance_info_get.c tx_thread_performance_system_info_get.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_performance_info_get.c tx_timer_performance_system_info_get.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c tx_trace_buffer_full_notify.c tx_trace_disable.c tx_trace_enable.c tx_trace_event_filter.c tx_trace_event_unfilter.c tx_trace_initialize.c tx_trace_interrupt_control.c tx_trace_isr_enter_insert.c tx_trace_isr_exit_insert.c tx_trace_object_register.c tx_trace_object_unregister.c tx_trace_user_event_insert.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
  group Renesas_AP/libs/threadx/ports/rxv3/iar
    libs/threadx/ports/rxv3/iar/: readme_threadx.txt
  group Renesas_AP/libs/threadx/ports/rxv3/iar/inc
    libs/threadx/ports/rxv3/iar/inc/: tx_port.h
  group Renesas_AP/libs/threadx/ports/rxv3/iar/src
    libs/threadx/ports/rxv3/iar/src/: tx_initialize_low_level.s tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_control.s tx_thread_schedule.s tx_thread_stack_build.s tx_thread_system_return.s tx_timer_interrupt.s
  group Renesas_AP/libs/threadx/utility/low_power
    libs/threadx/utility/low_power/: low_power.md tx_low_power.c tx_low_power.h
  group Renesas_AP/src/rtos_config
    src/rtos_config/: azurertos_object_init.c azurertos_object_init.h
  group Renesas_AP/src/smc_gen/general
    src/smc_gen/general/: r_cg_hardware_setup.c r_cg_macrodriver.h r_cg_userdefine.h r_smc_cgc.c r_smc_cgc.h r_smc_cgc_user.c r_smc_entry.h r_smc_interrupt.c r_smc_interrupt.h
  group Renesas_AP/src/smc_gen/r_bsp
    src/smc_gen/r_bsp/: platform.h readme.txt
  group Renesas_AP/src/smc_gen/r_bsp/board/generic_rx26t
    src/smc_gen/r_bsp/board/generic_rx26t/: hwsetup.c hwsetup.h r_bsp.h r_bsp_config_reference.h r_bsp_interrupt_config_reference.h
  group Renesas_AP/src/smc_gen/r_bsp/board/user
    src/smc_gen/r_bsp/board/user/: r_bsp.h
  group Renesas_AP/src/smc_gen/r_bsp/doc/en
    src/smc_gen/r_bsp/doc/en/: r01an1685ej0741-rx-bsp.pdf
  group Renesas_AP/src/smc_gen/r_bsp/doc/ja
    src/smc_gen/r_bsp/doc/ja/: r01an1685jj0741-rx-bsp.pdf
  group Renesas_AP/src/smc_gen/r_bsp/mcu/all
    src/smc_gen/r_bsp/mcu/all/: fsp_common_api.h iar_call_inits.s lowlvl.c lowlvl.h lowsrc.c lowsrc.h mcu_locks.c r_bsp_common.c r_bsp_common.h r_bsp_cpu.c r_bsp_interrupts.c r_bsp_interrupts.h r_bsp_locking.c r_bsp_mcu_startup.c r_bsp_mcu_startup.h r_bsp_software_interrupt.c r_bsp_software_interrupt.h r_fsp_error.h r_rtos.h r_rx_compiler.h r_rx_intrinsic_functions.c r_rx_intrinsic_functions.h r_typedefs.h resetprg.c
  group Renesas_AP/src/smc_gen/r_bsp/mcu/rx26t
    src/smc_gen/r_bsp/mcu/rx26t/: mcu_clocks.c mcu_clocks.h mcu_info.h mcu_init.c mcu_init.h mcu_interrupts.c mcu_interrupts.h mcu_locks.h mcu_mapped_interrupts.c mcu_mapped_interrupts.h mcu_mapped_interrupts_private.h r_bsp_cpu.h r_bsp_locking.h vecttbl.c vecttbl.h
  group Renesas_AP/src/smc_gen/r_bsp/mcu/rx26t/register_access/iccrx
    src/smc_gen/r_bsp/mcu/rx26t/register_access/iccrx/: iodefine.h
  group Renesas_AP/src/smc_gen/r_cmt_rx
    src/smc_gen/r_cmt_rx/: r_cmt_rx_if.h readme.txt
  group Renesas_AP/src/smc_gen/r_cmt_rx/doc/en
    src/smc_gen/r_cmt_rx/doc/en/: r01an1856ej0550-rx-timer.pdf
  group Renesas_AP/src/smc_gen/r_cmt_rx/doc/ja
    src/smc_gen/r_cmt_rx/doc/ja/: r01an1856jj0550-rx-timer.pdf
  group Renesas_AP/src/smc_gen/r_cmt_rx/src
    src/smc_gen/r_cmt_rx/src/: r_cmt_rx.c
  group Renesas_AP/src/smc_gen/r_config
    src/smc_gen/r_config/: r_bsp_config.h r_bsp_config_readme.txt r_bsp_interrupt_config.h r_cmt_rx_config.h
  group Renesas_AP/src/smc_gen/r_pincfg
    src/smc_gen/r_pincfg/: Pin.c Pin.h

# IAR project Tutorial_withTFT.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F565NE_DUAL R5F565NE_DUAL
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x800
  General.IStackSize: 0x800
  General.HeapSize: 0x800
  ICCRX.CCDiagSuppress: Pa084,Pa082
  ICCRX.CCIncludePath2: src\smc_gen\Config_CMT0; src\smc_gen\Config_CMT1; src\smc_gen\Config_CMT2; src\smc_gen\Config_ICU; src\smc_gen\Config_PORT; src\smc_gen\Config_S12AD0; src\smc_gen\Config_SCI6; src\smc_gen\Config_SCI8; src\smc_gen\general; src\smc_gen\r_bsp; src\smc_gen\r_config; src\smc_gen\r_pincfg; src; src\tft\r_glcdc_rx; src\tft\r_config; src\tft\r_pincfg
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: RSK+RX65N-2MB.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Tutorial_withTFT.ipcf
  group doc
    src/doc/: Description.txt RSK_Header.txt
  group Renesas_AP/smc_gen/Config_CMT0
    src/smc_gen/Config_CMT0/: Config_CMT0.c Config_CMT0.h Config_CMT0_user.c
  group Renesas_AP/smc_gen/Config_CMT1
    src/smc_gen/Config_CMT1/: Config_CMT1.c Config_CMT1.h Config_CMT1_user.c
  group Renesas_AP/smc_gen/Config_CMT2
    src/smc_gen/Config_CMT2/: Config_CMT2.c Config_CMT2.h Config_CMT2_user.c
  group Renesas_AP/smc_gen/Config_ICU
    src/smc_gen/Config_ICU/: Config_ICU.c Config_ICU.h Config_ICU_user.c
  group Renesas_AP/smc_gen/Config_PORT
    src/smc_gen/Config_PORT/: Config_PORT.c Config_PORT.h Config_PORT_user.c
  group Renesas_AP/smc_gen/Config_S12AD0
    src/smc_gen/Config_S12AD0/: Config_S12AD0.c Config_S12AD0.h Config_S12AD0_user.c
  group Renesas_AP/smc_gen/Config_SCI6
    src/smc_gen/Config_SCI6/: Config_SCI6.c Config_SCI6.h Config_SCI6_user.c
  group Renesas_AP/smc_gen/Config_SCI8
    src/smc_gen/Config_SCI8/: Config_SCI8.c Config_SCI8.h Config_SCI8_user.c
  group Renesas_AP/smc_gen/general
    src/smc_gen/general/: r_cg_cmt.h r_cg_cmtw.h r_cg_hardware_setup.c r_cg_icu.h r_cg_macrodriver.h r_cg_port.h r_cg_rspi.h r_cg_s12ad.h r_cg_sci.h r_cg_userdefine.h r_smc_cgc.c r_smc_cgc.h r_smc_cgc_user.c r_smc_entry.h r_smc_interrupt.c r_smc_interrupt.h
  group Renesas_AP/smc_gen/r_bsp
    src/smc_gen/r_bsp/: platform.h readme.txt
  group Renesas_AP/smc_gen/r_bsp/board/generic_rx65n
    src/smc_gen/r_bsp/board/generic_rx65n/: hwsetup.c hwsetup.h r_bsp.h r_bsp_config_reference.h r_bsp_interrupt_config_reference.h resetprg.c vecttbl.c vecttbl.h
  group Renesas_AP/smc_gen/r_bsp/mcu/all
    src/smc_gen/r_bsp/mcu/all/: r_bsp_common.c r_bsp_common.h r_typedefs.h
  group Renesas_AP/smc_gen/r_bsp/mcu/rx65n
    src/smc_gen/r_bsp/mcu/rx65n/: cpu.c cpu.h locking.c locking.h mcu_clocks.c mcu_info.h mcu_init.c mcu_init.h mcu_interrupts.c mcu_interrupts.h mcu_locks.c mcu_locks.h mcu_mapped_interrupts.c mcu_mapped_interrupts.h mcu_mapped_interrupts_private.h
  group Renesas_AP/smc_gen/r_bsp/mcu/rx65n/register_access
    src/smc_gen/r_bsp/mcu/rx65n/register_access/: iodefine.h
  group Renesas_AP/smc_gen/r_config
    src/smc_gen/r_config/: r_bsp_config.h r_bsp_config_readme.txt r_bsp_interrupt_config.h
  group Renesas_AP/smc_gen/r_pincfg
    src/smc_gen/r_pincfg/: Pin.c Pin.h
  group src
    src/: ascii.c ascii.h lcd_main.c main.c r_okaya_lcd.c r_okaya_lcd.h r_rsk_debug.c r_rsk_debug.h r_rsk_switch.c r_rsk_switch.h rskrx65n2mbdef.h
  group tft/r_config
    src/tft/r_config/: r_glcdc_rx_config.h
  group tft/r_glcdc_rx
    src/tft/r_glcdc_rx/: r_glcdc_rx_if.h
  group tft/r_glcdc_rx/ref
    src/tft/r_glcdc_rx/ref/: r_glcdc_rx_config_reference.h
  group tft/r_glcdc_rx/src
    src/tft/r_glcdc_rx/src/: r_glcdc_private.c r_glcdc_private.h r_glcdc_rx.c
  group tft/r_glcdc_rx/src/targets/rx65n
    src/tft/r_glcdc_rx/src/targets/rx65n/: r_glcdc_rx65n.c
  group tft/r_pincfg
    src/tft/r_pincfg/: r_glcdc_rx_pinset.c r_glcdc_rx_pinset.h r_pinset.h

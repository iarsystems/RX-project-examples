# IAR project System_Input_Capture.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F565NE_DUAL R5F565NE_DUAL
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x400
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDiagSuppress: Pa050,Pe009,Pe301,Pa082
  ICCRX.CCIncludePath2: src; src/smc_gen/r_bsp; src/smc_gen/r_config; src/smc_gen/Config_ICU; src/smc_gen/Config_PORT; src/smc_gen/Config_SCI6; src/smc_gen/Config_SCI8; src/smc_gen/Config_CMT0; src/smc_gen/Config_CMT3; src/smc_gen/Config_LPC; src/smc_gen/Config_RIIC0; src/smc_gen/Config_RTC; src/smc_gen/Config_S12AD1; src/smc_gen/Config_S12AD0; src/smc_gen/general; src/smc_gen/r_pincfg; src\smc_gen\Config_CMT3; src\smc_gen\Config_LPC; src\smc_gen\Config_RIIC0; src\smc_gen\Config_RTC; src\smc_gen\Config_S12AD0; src\smc_gen\Config_S12AD1; src\smc_gen\Config_SCI8
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: System_Input_Capture.ipcf
  group doc
    doc/: Description.txt RSK_Header.txt
  group Renesas_AP/smc_gen/Config_CMT0
    src/smc_gen/Config_CMT0/: Config_CMT0.c Config_CMT0.h Config_CMT0_user.c
  group Renesas_AP/smc_gen/Config_CMT3
    src/smc_gen/Config_CMT3/: Config_CMT3.c Config_CMT3.h Config_CMT3_user.c
  group Renesas_AP/smc_gen/Config_ICU
    src/smc_gen/Config_ICU/: Config_ICU.c Config_ICU.h Config_ICU_user.c
  group Renesas_AP/smc_gen/Config_LPC
    src/smc_gen/Config_LPC/: Config_LPC.c Config_LPC.h Config_LPC_user.c
  group Renesas_AP/smc_gen/Config_PORT
    src/smc_gen/Config_PORT/: Config_PORT.c Config_PORT.h Config_PORT_user.c
  group Renesas_AP/smc_gen/Config_RIIC0
    src/smc_gen/Config_RIIC0/: Config_RIIC0.c Config_RIIC0.h Config_RIIC0_user.c
  group Renesas_AP/smc_gen/Config_RTC
    src/smc_gen/Config_RTC/: Config_RTC.c Config_RTC.h Config_RTC_user.c
  group Renesas_AP/smc_gen/Config_S12AD0
    src/smc_gen/Config_S12AD0/: Config_S12AD0.c Config_S12AD0.h Config_S12AD0_user.c
  group Renesas_AP/smc_gen/Config_S12AD1
    src/smc_gen/Config_S12AD1/: Config_S12AD1.c Config_S12AD1.h Config_S12AD1_user.c
  group Renesas_AP/smc_gen/Config_SCI6
    src/smc_gen/Config_SCI6/: Config_SCI6.c Config_SCI6.h Config_SCI6_user.c
  group Renesas_AP/smc_gen/Config_SCI8
    src/smc_gen/Config_SCI8/: Config_SCI8.c Config_SCI8.h Config_SCI8_user.c
  group Renesas_AP/smc_gen/general
    src/smc_gen/general/: r_cg_cmt.h r_cg_cmtw.h r_cg_hardware_setup.c r_cg_icu.h r_cg_lpc.h r_cg_macrodriver.h r_cg_port.h r_cg_riic.h r_cg_rspi.h r_cg_rtc.h r_cg_s12ad.h r_cg_sci.h r_cg_userdefine.h r_smc_cgc.c r_smc_cgc.h r_smc_cgc_user.c r_smc_entry.h r_smc_interrupt.c r_smc_interrupt.h
  group Renesas_AP/smc_gen/r_bsp
    src/smc_gen/r_bsp/: platform.h readme.txt
  group Renesas_AP/smc_gen/r_bsp/board/generic_rx65n
    src/smc_gen/r_bsp/board/generic_rx65n/: hwsetup.c hwsetup.h r_bsp.h r_bsp_config_reference.h r_bsp_interrupt_config_reference.h resetprg.c vecttbl.c vecttbl.h
  group Renesas_AP/smc_gen/r_bsp/mcu/all
    src/smc_gen/r_bsp/mcu/all/: r_bsp_common.c r_bsp_common.h r_typedefs.h
  group Renesas_AP/smc_gen/r_bsp/mcu/rx65n
    src/smc_gen/r_bsp/mcu/rx65n/: cpu.c cpu.h locking.c locking.h mcu_clocks.c mcu_info.h mcu_init.c mcu_init.h mcu_interrupts.c mcu_interrupts.h mcu_locks.c mcu_locks.h mcu_mapped_interrupts.c mcu_mapped_interrupts.h mcu_mapped_interrupts_private.h
  group Renesas_AP/smc_gen/r_bsp/mcu/rx65n/register_access
    src/smc_gen/r_bsp/mcu/rx65n/register_access/: iodefine.h
  group Renesas_AP/smc_gen/r_config
    src/smc_gen/r_config/: r_bsp_config.h r_bsp_config_readme.txt r_bsp_interrupt_config.h
  group Renesas_AP/smc_gen/r_pincfg
    src/smc_gen/r_pincfg/: Pin.c Pin.h
  group src
    src/: ascii.c ascii.h main.c r_okaya_lcd.c r_okaya_lcd.h r_rsk_iic_eeprom.c r_rsk_iic_eeprom.h r_rsk_nvm.c r_rsk_nvm.h rskrx65n2mbdef.h

# IAR project Async_Serial.ewp, settings and files
configuration Release (RX)
  General.OGChipSelectMenu: R5F523T5 R5F523T5
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: __RX
  ICCRX.CCIncludePath2: src/cg_src; src
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: Async_Serial.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration HardwareDebug (RX, debug)
  as the first configuration, except:
  General.StackSize: 0x400
  ICCRX.CCDiagSuppress: Pa050,Pe009,Pe301
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group (top)
    src/: cgproject.ipcf
  group doc
    doc/: description.txt RSK_Header.txt
  group Renesas_AP/cg_src
    src/cg_src/: r_cg_cgc.c r_cg_cgc.h r_cg_cgc_user.c r_cg_cmt.c r_cg_cmt.h r_cg_cmt_user.c r_cg_intprg.c r_cg_macrodriver.h r_cg_main.c r_cg_port.c r_cg_port.h r_cg_port_user.c r_cg_sci.c r_cg_sci.h r_cg_sci_user.c r_cg_systeminit.c r_cg_userdefine.h
  group src
    src/: ascii.c ascii.h iodefine.h r_okaya_lcd.c r_okaya_lcd.h r_rsk_async.c r_rsk_async.h rskrx23tdef.h

# IAR project System_BootLoader_Application.ewp, settings and files
configuration HardwareDebug (RX, debug)
  General.OGChipSelectMenu: R5F51138 R5F51138
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x300
  General.HeapSize: 0x200
  ICCRX.CCDefines: __RX
  ICCRX.CCIncludePath2: src; src/cg_src
  ICCRX.IccLang: 0
  OBJCOPY.OOCOutputFile: System_BootLoader_Application.hex
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkIcfFile: linker\lnkr5f51138.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group cg/cg_src
    src/cg_src/: r_cg_cgc.c r_cg_cgc_user.c r_cg_cmt.c r_cg_cmt_user.c r_cg_icu.c r_cg_icu_user.c r_cg_intprg.c r_cg_iwdt.c r_cg_iwdt_user.c r_cg_main.c r_cg_port.c r_cg_port_user.c r_cg_sci.c r_cg_sci_user.c r_cg_systeminit.c
  group doc
    doc/: description.txt RSK_Header.txt
  group linker
    linker/: lnkr5f51138.icf
  group src
    src/: r_lcd_appv2.c r_rsk_async.c

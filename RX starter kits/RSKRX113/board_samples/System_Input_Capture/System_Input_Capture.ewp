# IAR project System_Input_Capture.ewp, settings and files
configuration HardwareDebug (RX, debug)
  General.OGChipSelectMenu: R5F51138 R5F51138
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x400
  General.IStackSize: 0x400
  General.HeapSize: 0x400
  ICCRX.CCDefines: __RX
  ICCRX.CCDiagSuppress: Pa050
  ICCRX.CCIncludePath2: .; src; src/cg_src; r_bsp; r_bsp/board/rskrx113; r_bsp/board/user; r_bsp/mcu/all; r_bsp/mcu/rx113; r_config; r_flash_rx; r_flash_rx/ref; r_flash_rx/src; r_flash_rx/src/fcu; r_flash_rx/src/MF3_Flash/rx100; r_flash_rx/src/targets/rx113
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group cg/cg_src
    src/cg_src/: r_cg_cmt.c r_cg_cmt_user.c r_cg_icu.c r_cg_icu_user.c r_cg_intprg.c r_cg_lpc.c r_cg_lpc_user.c r_cg_main.c r_cg_port.c r_cg_port_user.c r_cg_riic.c r_cg_riic_user.c r_cg_rtc.c r_cg_rtc_user.c r_cg_s12ad.c r_cg_s12ad_user.c r_cg_sci.c r_cg_sci_user.c
  group doc
    doc/: description.txt RSK_Header.txt
  group r_bsp
    r_bsp/: readme.txt
  group r_bsp/board/rskrx113
    r_bsp/board/rskrx113/: getchar.c hwsetup.c hwsetup.h low_level_init.c lowlvl.c putchar.c
  group r_bsp/doc
    r_bsp/doc/: r01an1685eu0280_rx.pdf
  group r_bsp/mcu/all
    r_bsp/mcu/all/: r_bsp_common.c
  group r_bsp/mcu/rx113
    r_bsp/mcu/rx113/: cpu.c locking.c mcu_init.c mcu_interrupts.c mcu_locks.c
  group r_config
    r_config/: readme.txt
  group r_flash_rx
    r_flash_rx/: readme.txt
  group r_flash_rx/ref
    r_flash_rx/ref/: r_flash_rx_config_reference.h
  group r_flash_rx/src
    r_flash_rx/src/: r_flash_rx.c
  group r_flash_rx/src/fcu
    r_flash_rx/src/fcu/: r_flash_fcu_64m_rx.c r_flash_fcu_rx.c
  group r_flash_rx/src/MF3_Flash/rx100
    r_flash_rx/src/MF3_Flash/rx100/: r_codeflash_extra_rx100.c r_codeflash_rx100.c r_dataflash_rx100.c r_flash_rx100_rx.c r_flash_utils.c
  group src
    src/: r_lcd_appv2.c r_rsk_async.c r_rsk_iic_eeprom.c r_rsk_nvm.c r_rsk_utility.c

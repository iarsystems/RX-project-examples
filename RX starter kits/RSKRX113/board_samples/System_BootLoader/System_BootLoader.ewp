# IAR project System_BootLoader.ewp, settings and files
configuration HardwareDebug (RX, debug)
  General.OGChipSelectMenu: R5F51138 R5F51138
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: __RX
  ICCRX.CCIncludePath2: src; src\cg_src; r_config; r_flash_rx; r_flash_rx\ref; r_flash_rx\src; r_flash_rx\src\fcu; r_flash_rx\src\MF3_Flash\rx100; r_flash_rx\src\targets\rx113; u_bsp
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkIcfFile: linker\boot_loader.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group cg/cg_src
    src/cg_src/: r_cg_cgc.c r_cg_cgc_user.c r_cg_cmt.c r_cg_cmt_user.c r_cg_crc.c r_cg_iwdt.c r_cg_iwdt_user.c r_cg_main.c r_cg_port.c r_cg_port_user.c r_cg_sci.c r_cg_sci_user.c r_cg_systeminit.c
  group doc
    doc/: description.txt RSK_Header.txt
  group linker
    linker/: boot_loader.icf
  group r_config
    r_config/: r_flash_rx_config.h
  group r_flash_rx
    r_flash_rx/: readme.txt
  group r_flash_rx/doc
    r_flash_rx/doc/: r01an2184eu0105_rx.pdf
  group r_flash_rx/src
    r_flash_rx/src/: r_flash_rx.c
  group r_flash_rx/src/fcu
    r_flash_rx/src/fcu/: r_flash_fcu_64m_rx.c r_flash_fcu_rx.c
  group r_flash_rx/src/MF3_Flash/rx100
    r_flash_rx/src/MF3_Flash/rx100/: r_codeflash_extra_rx100.c r_codeflash_rx100.c r_dataflash_rx100.c r_flash_rx100_rx.c r_flash_utils.c
  group src
    src/: buffer.c code_flash.c crc.c hex.c r_bootloader_intprg.c r_rsk_utility.c srec.c xmodem.c
  group u_bsp
    u_bsp/: locking.c mcu_locks.c

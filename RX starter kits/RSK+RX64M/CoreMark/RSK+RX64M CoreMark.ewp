# IAR project RSK+RX64M CoreMark.ewp, settings and files
configuration 120 MHz (RX, debug)
  General.OGChipSelectMenu: R5F564ML R5F564ML
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x2000
  General.IStackSize: 0x2000
  General.HeapSize: 0x400
  ICCRX.CCDefines: CLOCK120MHZ
  ICCRX.CCIncludePath2: source_RX64M; CoreMark
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: RSK+RX71M CoreMark.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CoreMark
    CoreMark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
  group source_RX64M
    source_RX64M/: core_portme.c low_level_init.c r_cg_cgc.c r_cg_cgc_user.c r_cg_hardware_setup.c r_cg_intprg.c r_cg_mtu3.c r_cg_mtu3_user.c r_cg_port.c r_cg_port_user.c

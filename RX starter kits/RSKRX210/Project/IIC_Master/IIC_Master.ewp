# IAR project IIC_Master.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F52108A R5F52108A
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDiagSuppress: Pa082
  ICCRX.CCIncludePath2: ../RPDL
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: ../RPDL/RX210_library.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: hwsetup.c iic_eeprom_master.c iic_eeprom_master_app.c lcd.c main_iic_master.c switch.c
  group RPDL
    ../RPDL/: Interrupt_ADC_12.c Interrupt_BSC.c Interrupt_CAC.c Interrupt_CMT.c Interrupt_CPA_LVD.c Interrupt_CPB.c Interrupt_DMAC.c Interrupt_DOC.c Interrupt_ELC.c Interrupt_IIC.c Interrupt_INTC.c Interrupt_MTU2.c Interrupt_not_RPDL.c Interrupt_POE.c Interrupt_RTC.c Interrupt_SCI.c Interrupt_SPI.c Interrupt_TMR.c

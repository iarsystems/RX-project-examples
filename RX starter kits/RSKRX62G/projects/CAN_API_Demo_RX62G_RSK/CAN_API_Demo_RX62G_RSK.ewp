# IAR project CAN_API_Demo_RX62G_RSK.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F562GA R5F562GA
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDiagSuppress: Pa082
  ICCRX.CCIncludePath2: ..\RPDL\; r_bsp\; r_bsp\board\rskrx62g\; r_bsp\mcu\rx62g\
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: ..\RPDL\RX62G_library.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    src/: can_api_demo.c main.c r_can_api.c switches.c
    r_bsp/board/rskrx62g/: hwsetup.c lcd.c
  group RPDL
    ../RPDL/: Interrupt_ADC_10.c Interrupt_ADC_12.c Interrupt_BSC.c Interrupt_CMT.c Interrupt_GPT.c Interrupt_IIC.c Interrupt_INTC.c Interrupt_LIN.c Interrupt_MTU3.c Interrupt_not_RPDL.c Interrupt_POE.c Interrupt_SCI.c Interrupt_SPI.c Interrupt_WDT.c
  group Text Files
    ./: Description.txt RSK_Header.txt

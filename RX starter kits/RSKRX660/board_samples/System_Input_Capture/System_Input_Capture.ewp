# IAR project System_Input_Capture.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F56609H R5F56609H
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x800
  General.IStackSize: 0x800
  General.HeapSize: 0x800
  ICCRX.CCIncludePath2: src; src/smc_gen/r_flash_rx/src/flash_type_3; src/smc_gen/r_flash_rx/src; src/smc_gen/Config_CMT0; src/smc_gen/Config_CMT3; src/smc_gen/Config_ICU; src/smc_gen/Config_LPC; src/smc_gen/Config_PORT; src/smc_gen/Config_RIIC0; src/smc_gen/Config_RTC; src/smc_gen/Config_S12AD0; src/smc_gen/Config_SCI10; src/smc_gen/Config_SCI6; src/smc_gen/general; src/smc_gen/r_bsp; src/smc_gen/r_config; src/smc_gen/r_flash_rx; src/smc_gen/r_pincfg
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: System_Input_Capture.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    src/: ascii.c main.c r_okaya_lcd.c r_rsk_flash_data.c r_rsk_iic_eeprom.c r_rsk_nvm.c
    ./: buildinfo.ipcf
  group Renesas_AP/src/smc_gen/Config_CMT0
    src/smc_gen/Config_CMT0/: Config_CMT0.c Config_CMT0.h Config_CMT0_user.c
  group Renesas_AP/src/smc_gen/Config_CMT3
    src/smc_gen/Config_CMT3/: Config_CMT3.c Config_CMT3.h Config_CMT3_user.c
  group Renesas_AP/src/smc_gen/Config_ICU
    src/smc_gen/Config_ICU/: Config_ICU.c Config_ICU.h Config_ICU_user.c
  group Renesas_AP/src/smc_gen/Config_LPC
    src/smc_gen/Config_LPC/: Config_LPC.c Config_LPC.h Config_LPC_user.c
  group Renesas_AP/src/smc_gen/Config_PORT
    src/smc_gen/Config_PORT/: Config_PORT.c Config_PORT.h Config_PORT_user.c
  group Renesas_AP/src/smc_gen/Config_RIIC0
    src/smc_gen/Config_RIIC0/: Config_RIIC0.c Config_RIIC0.h Config_RIIC0_user.c
  group Renesas_AP/src/smc_gen/Config_RTC
    src/smc_gen/Config_RTC/: Config_RTC.c Config_RTC.h Config_RTC_user.c
  group Renesas_AP/src/smc_gen/Config_S12AD0
    src/smc_gen/Config_S12AD0/: Config_S12AD0.c Config_S12AD0.h Config_S12AD0_user.c
  group Renesas_AP/src/smc_gen/Config_SCI10
    src/smc_gen/Config_SCI10/: Config_SCI10.c Config_SCI10.h Config_SCI10_user.c
  group Renesas_AP/src/smc_gen/Config_SCI6
    src/smc_gen/Config_SCI6/: Config_SCI6.c Config_SCI6.h Config_SCI6_user.c
  group Renesas_AP/src/smc_gen/general
    src/smc_gen/general/: r_cg_cmt.h r_cg_hardware_setup.c r_cg_icu.h r_cg_lpc.h r_cg_macrodriver.h r_cg_port.h r_cg_riic.h r_cg_rtc.h r_cg_s12ad.h r_cg_sci.h r_cg_userdefine.h r_smc_cgc.c r_smc_cgc.h r_smc_cgc_user.c r_smc_entry.h r_smc_interrupt.c r_smc_interrupt.h
  group Renesas_AP/src/smc_gen/r_bsp
    src/smc_gen/r_bsp/: platform.h readme.txt
  group Renesas_AP/src/smc_gen/r_bsp/board/generic_rx660
    src/smc_gen/r_bsp/board/generic_rx660/: hwsetup.c hwsetup.h r_bsp.h r_bsp_config_reference.h r_bsp_interrupt_config_reference.h
  group Renesas_AP/src/smc_gen/r_bsp/board/user
    src/smc_gen/r_bsp/board/user/: r_bsp.h
  group Renesas_AP/src/smc_gen/r_bsp/doc/en
    src/smc_gen/r_bsp/doc/en/: r01an1685ej0720-rx-bsp.pdf
  group Renesas_AP/src/smc_gen/r_bsp/doc/ja
    src/smc_gen/r_bsp/doc/ja/: r01an1685jj0720-rx-bsp.pdf
  group Renesas_AP/src/smc_gen/r_bsp/mcu/all
    src/smc_gen/r_bsp/mcu/all/: fsp_common_api.h lowlvl.c lowlvl.h lowsrc.c lowsrc.h mcu_locks.c r_bsp_common.c r_bsp_common.h r_bsp_cpu.c r_bsp_interrupts.c r_bsp_interrupts.h r_bsp_locking.c r_bsp_mcu_startup.c r_bsp_mcu_startup.h r_bsp_software_interrupt.c r_bsp_software_interrupt.h r_fsp_error.h r_rtos.h r_rx_compiler.h r_rx_intrinsic_functions.c r_rx_intrinsic_functions.h r_typedefs.h resetprg.c
  group Renesas_AP/src/smc_gen/r_bsp/mcu/rx660
    src/smc_gen/r_bsp/mcu/rx660/: mcu_clocks.c mcu_clocks.h mcu_info.h mcu_init.c mcu_init.h mcu_interrupts.c mcu_interrupts.h mcu_locks.h mcu_mapped_interrupts.c mcu_mapped_interrupts.h mcu_mapped_interrupts_private.h r_bsp_cpu.h r_bsp_locking.h vecttbl.c vecttbl.h
  group Renesas_AP/src/smc_gen/r_bsp/mcu/rx660/register_access/iccrx
    src/smc_gen/r_bsp/mcu/rx660/register_access/iccrx/: iodefine.h
  group Renesas_AP/src/smc_gen/r_config
    src/smc_gen/r_config/: r_bsp_config.h r_bsp_config_readme.txt r_bsp_interrupt_config.h r_flash_rx_config.h
  group Renesas_AP/src/smc_gen/r_flash_rx
    src/smc_gen/r_flash_rx/: r_flash_rx_if.h readme.txt
  group Renesas_AP/src/smc_gen/r_flash_rx/doc/en
    src/smc_gen/r_flash_rx/doc/en/: r01an2184ej0490-rx-flash.pdf
  group Renesas_AP/src/smc_gen/r_flash_rx/doc/ja
    src/smc_gen/r_flash_rx/doc/ja/: r01an2184jj0490-rx-flash.pdf
  group Renesas_AP/src/smc_gen/r_flash_rx/src
    src/smc_gen/r_flash_rx/src/: r_flash_fcu.c r_flash_fcu.h r_flash_group.c r_flash_group.h r_flash_nofcu.c r_flash_nofcu.h r_flash_rx.c r_flash_rx.h r_flash_targets.h
  group Renesas_AP/src/smc_gen/r_flash_rx/src/flash_type_1
    src/smc_gen/r_flash_rx/src/flash_type_1/: r_flash_type1.c r_flash_type1_if.h
  group Renesas_AP/src/smc_gen/r_flash_rx/src/flash_type_3
    src/smc_gen/r_flash_rx/src/flash_type_3/: r_flash_type3.c r_flash_type3_if.h
  group Renesas_AP/src/smc_gen/r_flash_rx/src/flash_type_4
    src/smc_gen/r_flash_rx/src/flash_type_4/: r_flash_type4.c r_flash_type4_if.h
  group Renesas_AP/src/smc_gen/r_flash_rx/src/targets/rx660
    src/smc_gen/r_flash_rx/src/targets/rx660/: r_flash_rx660.h
  group Renesas_AP/src/smc_gen/r_pincfg
    src/smc_gen/r_pincfg/: Pin.c Pin.h

# IAR project IIC_Slave.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F5630E R5F5630E
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x100
  General.IStackSize: 0x300
  General.HeapSize: 0x400
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: hwsetup.c iic_eeprom_slave.c iic_eeprom_slave_app.c lcd.c main_iic_slave.c switch.c

# IAR project Voltage_Detect.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F5630E R5F5630E
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x100
  General.IStackSize: 0x300
  General.HeapSize: 0x400
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$/inc/
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: hwsetup.c lcd.c main_voltage_detect.c switch.c voltage_detect.c

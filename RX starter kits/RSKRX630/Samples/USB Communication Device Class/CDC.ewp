# IAR project CDC.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F5630E R5F5630E
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x100
  General.IStackSize: 0x300
  General.HeapSize: 0x400
  ICCRX.CCDiagSuppress: Pa082
  ICCRX.CCIncludePath2: USBStack/; USBStack/CDC/; 
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$/inc/
  OBJCOPY.OOCOutputFile: CDC.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: async.c hwsetup.c lcd.c main_usb_cdc.c switch.c usb_cdc_app.c
  group USBStack
    USBStack/: usb_common.h usb_core.c usb_core.h usb_hal.c usb_hal.h
  group USBStack/CDC
    USBStack/CDC/: usb_cdc.c usb_cdc.h usbdescriptors.c usbdescriptors.h

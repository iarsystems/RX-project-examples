# IAR project IIC_Master.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F5630E R5F5630E
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x100
  General.IStackSize: 0x300
  General.HeapSize: 0x400
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$/inc/
  OBJCOPY.OOCOutputFile: IIC_Master.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: hwsetup.c iic_eeprom_master.c iic_eeprom_master_app.c lcd.c main_iic_master.c switch.c

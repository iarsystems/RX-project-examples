# IAR project CoreMark.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F566TE R5F566TE
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x800
  General.IStackSize: 0x800
  General.HeapSize: 0x800
  ICCRX.CCDefines: CLOCK160MHZ
  ICCRX.CCIncludePath2: src; src/smc_gen/Config_CMT0; src/smc_gen/Config_CMT1; src/smc_gen/Config_CMT2; src/smc_gen/Config_ICU; src/smc_gen/Config_MTU9; src/smc_gen/Config_PORT; src/smc_gen/Config_SCI6; src/smc_gen/general; src/smc_gen/r_bsp; src/smc_gen/r_config; src/smc_gen/r_pincfg
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: Timer_PWM.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CoreMark
    CoreMark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_portme.h core_state.c core_util.c coremark.h
  group Renesas_AP/smc_gen/Config_CMT0
    src/smc_gen/Config_CMT0/: Config_CMT0.c Config_CMT0.h Config_CMT0_user.c
  group Renesas_AP/smc_gen/Config_CMT1
    src/smc_gen/Config_CMT1/: Config_CMT1.c Config_CMT1.h Config_CMT1_user.c
  group Renesas_AP/smc_gen/Config_CMT2
    src/smc_gen/Config_CMT2/: Config_CMT2.c Config_CMT2.h Config_CMT2_user.c
  group Renesas_AP/smc_gen/Config_ICU
    src/smc_gen/Config_ICU/: Config_ICU.c Config_ICU.h Config_ICU_user.c
  group Renesas_AP/smc_gen/Config_MTU9
    src/smc_gen/Config_MTU9/: Config_MTU9.c Config_MTU9.h Config_MTU9_user.c
  group Renesas_AP/smc_gen/Config_PORT
    src/smc_gen/Config_PORT/: Config_PORT.c Config_PORT.h Config_PORT_user.c
  group Renesas_AP/smc_gen/Config_SCI6
    src/smc_gen/Config_SCI6/: Config_SCI6.c Config_SCI6.h Config_SCI6_user.c
  group Renesas_AP/smc_gen/general
    src/smc_gen/general/: r_cg_cmt.h r_cg_hardware_setup.c r_cg_icu.h r_cg_macrodriver.h r_cg_mtu3.h r_cg_port.h r_cg_rspi.h r_cg_sci.h r_cg_userdefine.h r_smc_cgc.c r_smc_cgc.h r_smc_cgc_user.c r_smc_entry.h r_smc_interrupt.c r_smc_interrupt.h
  group Renesas_AP/smc_gen/r_bsp
    src/smc_gen/r_bsp/: platform.h readme.txt
  group Renesas_AP/smc_gen/r_bsp/board/generic_rx66t
    src/smc_gen/r_bsp/board/generic_rx66t/: hwsetup.c hwsetup.h r_bsp.h r_bsp_config_reference.h r_bsp_interrupt_config_reference.h resetprg.c vecttbl.c vecttbl.h vollevel.asm
  group Renesas_AP/smc_gen/r_bsp/doc/en
    src/smc_gen/r_bsp/doc/en/: r20an0504es0101-smartconfigurator.pdf
  group Renesas_AP/smc_gen/r_bsp/doc/ja
    src/smc_gen/r_bsp/doc/ja/: r20an0504js0101-smartconfigurator.pdf
  group Renesas_AP/smc_gen/r_bsp/mcu/all
    src/smc_gen/r_bsp/mcu/all/: r_bsp_common.c r_bsp_common.h r_typedefs.h
  group Renesas_AP/smc_gen/r_bsp/mcu/rx66t
    src/smc_gen/r_bsp/mcu/rx66t/: cpu.c cpu.h locking.c locking.h mcu_clocks.c mcu_info.h mcu_init.c mcu_init.h mcu_interrupts.c mcu_interrupts.h mcu_locks.c mcu_locks.h mcu_mapped_interrupts.c mcu_mapped_interrupts.h mcu_mapped_interrupts_private.h
  group Renesas_AP/smc_gen/r_bsp/mcu/rx66t/register_access
    src/smc_gen/r_bsp/mcu/rx66t/register_access/: iodefine.h
  group Renesas_AP/smc_gen/r_config
    src/smc_gen/r_config/: r_bsp_config.h r_bsp_config_readme.txt r_bsp_interrupt_config.h
  group Renesas_AP/smc_gen/r_pincfg
    src/smc_gen/r_pincfg/: Pin.c Pin.h
  group src
    src/: ascii.c ascii.h r_okaya_lcd.c r_okaya_lcd.h r_rsk_switch.c r_rsk_switch.h r_rsk_utility.c r_rsk_utility.h rskrx66tdef.h

# IAR project System_Input_Capture.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F571ML R5F571ML
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x1024
  General.HeapSize: 0x400
  ICCRX.CCDiagSuppress: Pa050,Pa082,Pa118,Pe186,Pe191,Pa093
  ICCRX.CCDefines: __RX
  ICCRX.CCIncludePath2: src\; src\cg_src\; r_bsp\; r_bsp\board\rskrx71m\; r_bsp\board\user\; r_bsp\mcu\; r_bsp\mcu\all\; r_bsp\mcu\rx71m\; r_config\; r_flash_api_rx\; r_flash_api_rx\ref\; r_flash_api_rx\src\; r_flash_api_rx\src\targets\rx71x\
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: src\; src\cg_src\; r_bsp\; r_bsp\board\rskrx64m\; r_bsp\board\user\; r_bsp\mcu\; r_bsp\mcu\all\; r_bsp\mcu\rx64m\; r_config\; r_flash_api_rx\; r_flash_api_rx\ref\; r_flash_api_rx\src\; r_flash_api_rx\src\targets\rx64x\
  ILINK.IlinkOutputFile: System_Input_Capture.out
  ILINK.IlinkIcfFile: linker\lnkr5f564ml.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Description.txt
  group r_bsp
    r_bsp/: readme.txt
  group r_bsp/board/rksrk71m
    r_bsp/board/rskrx71m/: hwsetup.c low_level_init.c operating_frequency_set.c
  group r_bsp/mcu/all
    r_bsp/mcu/all/: r_bsp_common.c
  group r_bsp/mcu/rx71m
    r_bsp/mcu/rx71m/: cpu.c locking.c mcu_init.c mcu_interrupts.c mcu_locks.c mcu_mapped_interrupts.c
  group r_config
    r_config/: readme.txt
  group r_flash_api_rx
    r_flash_api_rx/: readme.txt
  group r_flash_api_rx/src
    r_flash_api_rx/src/: r_flash_api_rx.c
  group r_flash_api_rx/src/targets/rx71x
    r_flash_api_rx/src/targets/rx71x/: r_flash_api_rx71m.c
  group src
    src/: ascii.c r_okaya_lcd.c r_rsk_flash_data.c r_rsk_iic_eeprom.c r_rsk_nvm.c r_rsk_switch.c System_Input_Capture.c
  group src/cg_src
    src/cg_src/: r_cg_cmt.c r_cg_cmt_user.c r_cg_icu.c r_cg_icu_user.c r_cg_intprg.c r_cg_lpc.c r_cg_lpc_user.c r_cg_port.c r_cg_port_user.c r_cg_riic.c r_cg_riic_user.c r_cg_rtc.c r_cg_rtc_user.c r_cg_s12ad.c r_cg_s12ad_user.c r_cg_sci.c r_cg_sci_user.c

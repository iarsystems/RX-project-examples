# IAR project ADC_OneShot.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F571ML R5F571ML
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: ADC_OneShot.txt
    cg_src/: r_cg_cgc.c r_cg_cgc_user.c r_cg_intprg.c r_cg_main.c r_cg_s12ad.c r_cg_s12ad_user.c r_cg_systeminit.c r_cg_tmr.c r_cg_tmr_user.c

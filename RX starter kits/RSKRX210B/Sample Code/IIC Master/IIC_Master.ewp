# IAR project IIC_Master.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F5210BB R5F5210BB
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x200
  General.HeapSize: 0x400
  ICCRX.CCDiagSuppress: Pa082
  ICCRX.CCIncludePath2: $PROJ_DIR$; ../RPDL
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group C source file
    ./: hwsetup.c id_code_endian_ofs_.c iic_eeprom_master.c iic_eeprom_master_app.c lcd.c main_iic_master.c switch.c
  group C source file/RPDL
    ../RPDL/: Interrupt_ADC_12.c Interrupt_BSC.c Interrupt_CAC.c Interrupt_CMT.c Interrupt_CPA_LVD.c Interrupt_CPB.c Interrupt_DMAC.c Interrupt_DOC.c Interrupt_ELC.c Interrupt_IIC.c Interrupt_INTC.c Interrupt_MTU2.c Interrupt_not_RPDL.c Interrupt_POE.c Interrupt_RTC.c Interrupt_SCI.c Interrupt_SPI.c Interrupt_TMR.c Interrupt_TPU.c r_pdl_configuration.c RX210_library.lib
  group Text Files
    ./: Description.txt RSK_Header.txt

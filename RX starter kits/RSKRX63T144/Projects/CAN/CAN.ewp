# IAR project CAN.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F563TE R5F563TE
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: __RX
  ICCRX.CCDiagSuppress: Pa082,Go005
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group src
    src/: api_demo.c api_demo.h config_r_can_rapi.h Description.txt excep_BRK.c hwsetup.c hwsetup.h lcd.c lcd.h led.c led.h low_level_init.c main.c r_can_api.c r_can_api.h RSK_Header.txt rskrx63tdef.h switches.c switches.h typedefine.h

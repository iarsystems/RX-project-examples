# IAR project Timer_Capture.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F563TE R5F563TE
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: __RX
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group src
    src/: Description.txt excep_BRK.c hwsetup.c hwsetup.h lcd.c lcd.h low_level_init.c main_timer_capture.c main_timer_capture.h RSK_Header.txt rskrx63tdef.h switch.c switch.h timer_capture.c timer_capture.h typedefine.h

<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ADC_Oneshot\ADC_Oneshot.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ADC_Repeat\ADC_Repeat.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Application\Application.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Async_Serial\Async_Serial.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\CAC\CAC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\CAN\CAN.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\CRC\CRC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\DMAC\DMAC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\DTC\DTC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\IIC_Master\IIC_Master.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\IIC_Slave\IIC_Slave.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\IWDT\IWDT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Power_Down\Power_Down.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\PWM\PWM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SPI\SPI.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Sync_Serial\Sync_Serial.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Timer_Capture\Timer_Capture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Timer_Compare\Timer_Compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Timer_Event\Timer_Event.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Timer_Mode\Timer_Mode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Tutorial\Tutorial.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\USB_HMSC\USB_HMSC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\USB_PCDC\USB_PCDC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\USB_PHID\USB_PHID.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Voltage_Detect\Voltage_Detect.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\WDT\WDT.ewp</path>
  </project>
  <batchBuild/>
</workspace>



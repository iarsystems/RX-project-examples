# IAR project USB_PCDC.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F563TE R5F563TE
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x300
  General.HeapSize: 0x400
  ICCRX.CCDefines: USB_FW_PP=USB_FW_NONOS_PP; USBC_DEBUGLCD_PP; USB_UART_ENABLE
  ICCRX.CCDiagSuppress: Pe767,Pe549,Pe174
  ICCRX.CCIncludePath2: src/ANSI; src/CDCFW/include; src/HwResourceForUSB/inc; src/HwResourceForUSB/USBHW; src/HwResourceForUSB/USBHW/DEF; src/HwResourceForUSB/USBHW/REG; src/HwResourceForUSB/USRCFG; src/SmplMain/APL; src/USBSTDFW/include
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Description.txt RSK_Header.txt
  group cdc_inf
    cdc_inf/: CDC_Demo.inf CDC_Demo_Win7.inf
  group src/ANSI
    src/ANSI/: r_usb_ansi.c r_usb_ansi.h r_usb_ansi_host.c r_usb_ansi_peri.c r_usb_control.h r_usb_otherclass.c
  group src/CDCFW/include
    src/CDCFW/include/: r_usb_class_fusrcfg.h r_usb_class_usrcfg.h r_usb_pcdc_api.h r_usb_pcdc_define.h r_usb_pcdc_extern.h
  group src/CDCFW/PCDC
    src/CDCFW/PCDC/: r_usb_pcdc_ansi.c r_usb_pcdc_api.c r_usb_pcdc_driver.c
  group src/HwResourceForUSB
    src/HwResourceForUSB/: RX63T.txt
  group src/HwResourceForUSB/inc
    src/HwResourceForUSB/inc/: hw_resource.h lowsrc.h rx_mcu.h rx_rsk_extern.h sbrk.h stacksct.h typedefine.h
  group src/HwResourceForUSB/src
    src/HwResourceForUSB/src/: adcdriver.c excep_BRK.c hwsetup.c keydriver.c lcddriver.c leddriver.c lowsrc.c resetprg.c rx_mcu.c scidriver.c
  group src/HwResourceForUSB/USBHW
    src/HwResourceForUSB/USBHW/: iodefine.h r_usb_cusb_bitdefine.h
  group src/HwResourceForUSB/USBHW/DEF
    src/HwResourceForUSB/USBHW/DEF/: r_usb_defvalue.h r_usb_fixed_config.h r_usb_sysdef.h
  group src/HwResourceForUSB/USBHW/REG
    src/HwResourceForUSB/USBHW/REG/: r_usb_creg_abs.c r_usb_creg_access.c r_usb_creg_dmadtc.c r_usb_hostelectrical.c r_usb_hreg_abs.c r_usb_hreg_access.c r_usb_preg_abs.c r_usb_preg_access.c r_usb_reg_access.h
  group src/HwResourceForUSB/USRCFG
    src/HwResourceForUSB/USRCFG/: r_usb_usrconfig.h
  group src/SmplMain
    src/SmplMain/: main.c
  group src/SmplMain/APL
    src/SmplMain/APL/: r_usb_pcdc_apl.c r_usb_pcdc_descriptor.c
  group src/USBSTDFW/include
    src/USBSTDFW/include/: r_usb_api.h r_usb_cdefusbip.h r_usb_cextern.h r_usb_citron.h r_usb_ckernelid.h r_usb_cmacprint.h r_usb_cmacsystemcall.h r_usb_crevision.h r_usb_ctypedef.h
  group src/USBSTDFW/nonOS/class/hubd
    src/USBSTDFW/nonOS/class/hubd/: r_usb_hhubsys.c r_usb_hhubsys_uitron.c
  group src/USBSTDFW/nonOS/class/SMPL
    src/USBSTDFW/nonOS/class/SMPL/: r_usb_pclassvendor.c r_usb_smp_csub.c r_usb_smp_hsub.c
  group src/USBSTDFW/nonOS/USB20/HCD
    src/USBSTDFW/nonOS/USB20/HCD/: r_usb_hcontrolrw.c r_usb_hdriver.c r_usb_hdriverapi.c r_usb_hintfifo.c r_usb_hlibusbip.c r_usb_hmanager.c r_usb_hsignal.c r_usb_hstdfunction.c
  group src/USBSTDFW/nonOS/USB20/LIB
    src/USBSTDFW/nonOS/USB20/LIB/: r_usb_cdataio.c r_usb_cintfifo.c r_usb_cinthandler_usbip0.c r_usb_cinthandler_usbip1.c r_usb_clibusbip.c r_usb_cscheduler.c r_usb_cstdapi.c r_usb_cstdfunction.c
  group src/USBSTDFW/nonOS/USB20/PCD
    src/USBSTDFW/nonOS/USB20/PCD/: r_usb_pcontrolrw.c r_usb_pdriver.c r_usb_pdriverapi.c r_usb_pintfifo.c r_usb_psignal.c r_usb_pstdfunction.c r_usb_pstdrequest.c

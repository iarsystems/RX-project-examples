# IAR project IIC_Slave.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F563TE R5F563TE
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: __RX
  ICCRX.CCDiagSuppress: Pa124
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group src
    src/: Description.txt excep_BRK.c hwsetup.c hwsetup.h iic_eeprom_slave.c iic_eeprom_slave.h lcd.c lcd.h low_level_init.c main_iic_slave.c main_iic_slave.h RSK_Header.txt rskrx63tdef.h switch.c switch.h typedefine.h

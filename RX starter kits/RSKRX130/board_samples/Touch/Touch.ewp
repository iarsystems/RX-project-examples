# IAR project Touch.ewp, settings and files
configuration HardwareDebug (RX, debug)
  General.OGChipSelectMenu: R5F51305 R5F51305
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x400
  General.IStackSize: 0x400
  General.HeapSize: 0x400
  ICCRX.CCDefines: __RX; MAX_TS=36; MCU_SERIES_T=R5F5130; MCU_MODEL=MCU_MODEL_R5F51305AxFN
  ICCRX.CCDiagSuppress: Pa050,Pe009,Pe301,Pa082
  ICCRX.CCIncludePath2: src; Include/Workbench; Include/UsbBase; Include/UsbApp; Include/Touch; Include/SCI; Include/HwResource; Include/DTC; Include/CTSU; Include
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: lnkr5f51305.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group doc
    doc/: description.txt RSK_Header.txt
  group Include
    Include/: r_cg_userdefine.h r_touch_API.h
  group Include/CTSU
    Include/CTSU/: r_ctsu.h
  group Include/DTC
    Include/DTC/: r_dtc.h
  group Include/HwResource
    Include/HwResource/: iodefine.h r_cg_cmt.h r_cg_icu.h r_cg_macrodriver.h r_cg_port.h r_cg_sbrk.h r_cg_sci.h r_cg_stacksct.h r_cg_tmr.h r_cg_userdefine.h r_cg_vect.h r_cgc.h r_mpc.h
  group Include/SCI
    Include/SCI/: r_sci.h
  group Include/Touch
    Include/Touch/: r_touch.h
  group Include/UsbApp
    Include/UsbApp/: r_usb_pcdc_api.h r_usb_pcdc_define.h r_usb_pcdc_driver.h
  group Include/UsbBase
    Include/UsbBase/: hw_resource.h r_usb_api.h r_usb_cdefusbip.h r_usb_ckernelid.h r_usb_ctypedef.h r_usb_hport.h r_usb_iodefine.h r_usb_regaccess.h r_usb_usbip.h r_usb_usrconfig.h
  group Include/Workbench
    Include/Workbench/: r_mcu_model_define.h r_serial_control.h
  group src
    src/: ascii.c ascii.h interrupt_table.c r_main.c r_okaya_lcd.c r_okaya_lcd.h r_touch_API.c rskrx130def.h sbrk.h stacksct.h
  group src/CTSU
    src/CTSU/: r_ctsu.c r_ctsu_physical_driver.c
  group src/DTC
    src/DTC/: r_dtc.c
  group src/HwResource
    src/HwResource/: r_cg_cgc_user.c r_cg_cmt.c r_cg_cmt_user.c r_cg_dbsct.c r_cg_hardware_setup.c r_cg_icu.c r_cg_intprg.c r_cg_port.c r_cg_resetprg.c r_cg_sbrk.c r_cg_sci.c r_cg_sci_user.c r_cg_tmr.c r_cg_tmr_user.c r_cg_vecttbl.c r_cgc.c r_mpc.c rx_mcu.c
  group src/SCI
    src/SCI/: r_sci.c
  group src/Touch
    src/Touch/: r_touch.c
  group src/UsbApp
    src/UsbApp/: r_usb_pcdc_api.c r_usb_pcdc_apl.c r_usb_pcdc_apl_descriptor.c r_usb_pcdc_driver.c
  group src/UsbBase
    src/UsbBase/: r_usb_cstdapi.c r_usb_cstdfunction.c r_usb_pbc.c r_usb_pdriver.c r_usb_pdriverapi.c scidriver.c
  group src/Workbench
    src/Workbench/: r_serial_control.c

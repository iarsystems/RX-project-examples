# IAR project Tutorial.ewp, settings and files
configuration HardwareDebug (RX, debug)
  General.OGChipSelectMenu: R5F51305 R5F51305
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x400
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: __RX
  ICCRX.CCDiagSuppress: Pa050,Pe009,Pe301
  ICCRX.CCIncludePath2: src; src/cg_src
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    src/: cgproject.ipcf
  group doc
    doc/: description.txt RSK_Header.txt
  group Renesas_AP/cg_src
    src/cg_src/: r_cg_cgc.c r_cg_cgc.h r_cg_cgc_user.c r_cg_cmt.c r_cg_cmt.h r_cg_cmt_user.c r_cg_icu.c r_cg_icu.h r_cg_icu_user.c r_cg_intprg.c r_cg_macrodriver.h r_cg_main.c r_cg_port.c r_cg_port.h r_cg_port_user.c r_cg_s12ad.c r_cg_s12ad.h r_cg_s12ad_user.c r_cg_sci.c r_cg_sci.h r_cg_sci_user.c r_cg_systeminit.c r_cg_tmr.c r_cg_tmr.h r_cg_tmr_user.c r_cg_userdefine.h
  group src
    src/: ascii.c ascii.h iodefine.h r_okaya_lcd.c r_okaya_lcd.h r_rsk_debug.c r_rsk_debug.h r_rsk_switch.c r_rsk_switch.h rskrx130def.h

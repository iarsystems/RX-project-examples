# IAR project System_BootLoader.ewp, settings and files
configuration HardwareDebug (RX, debug)
  General.OGChipSelectMenu: R5F565N9 R5F565N9
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x400
  General.IStackSize: 0x400
  General.HeapSize: 0x400
  ICCRX.CCDefines: __RX
  ICCRX.CCDiagSuppress: Pa050,Pe009,Pe301
  ICCRX.CCIncludePath2: r_config; r_flash_rx; r_flash_rx/src; r_flash_rx/src/targets/rx65n; r_flash_rx/src/targets; r_flash_rx/src/flash_type_4; r_flash_rx/src/flash_type_3; r_flash_rx/src/flash_type_2; r_flash_rx/src/flash_type_1; src/cg_src; src; u_bsp
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    src/: cgproject.ipcf
    ./: ProjectConnection.ipcf
  group doc
    doc/: description.txt RSK_Header.txt
  group FIT Modules/r_config
    r_config/: r_bsp_config.h-3.40 r_bsp_config_readme.txt-3.40 r_bsp_interrupt_config.h-3.40
  group r_config
    r_config/: r_flash_rx_config.h
  group r_flash_rx
    r_flash_rx/: r_flash_rx_if.h readme.txt
  group r_flash_rx/doc
    r_flash_rx/doc/: r01an2184eu0170_rx.pdf
  group r_flash_rx/ref
    r_flash_rx/ref/: r_flash_rx_config_reference.h
  group r_flash_rx/src
    r_flash_rx/src/: r_flash_rx.c r_flash_rx.h
  group r_flash_rx/src/flash_type_1
    r_flash_rx/src/flash_type_1/: r_codeflash.c r_codeflash.h r_codeflash_extra.c r_codeflash_extra.h r_dataflash.c r_dataflash.h r_flash_common.h r_flash_type1.c r_flash_type1_if.h r_flash_utils.c
  group r_flash_rx/src/flash_type_2
    r_flash_rx/src/flash_type_2/: r_flash_type2.c r_flash_type2_if.h
  group r_flash_rx/src/flash_type_3
    r_flash_rx/src/flash_type_3/: r_flash_type3.c r_flash_type3_if.h
  group r_flash_rx/src/flash_type_4
    r_flash_rx/src/flash_type_4/: r_flash_type4.c r_flash_type4_if.h
  group r_flash_rx/src/targets/rx65n
    r_flash_rx/src/targets/rx65n/: r_flash_rx65n.h
  group Renesas_AP/cg_src
    src/cg_src/: r_cg_cgc.c r_cg_cgc.h r_cg_cgc_user.c r_cg_cmt.c r_cg_cmt.h r_cg_cmt_user.c r_cg_crc.c r_cg_crc.h r_cg_icu.c r_cg_icu.h r_cg_icu_user.c r_cg_intprg.c r_cg_iwdt.c r_cg_iwdt.h r_cg_iwdt_user.c r_cg_macrodriver.h r_cg_main.c r_cg_port.c r_cg_port.h r_cg_port_user.c r_cg_sci.c r_cg_sci.h r_cg_sci_user.c r_cg_systeminit.c r_cg_tmr.c r_cg_tmr.h r_cg_tmr_user.c r_cg_userdefine.h
  group src
    src/: buffer.c buffer.h code_flash.c code_flash.h crc.c crc.h hex.c hex.h iodefine.h r_rsk_utility.c r_rsk_utility.h rskrx65ndef.h srec.c srec.h xmodem.c xmodem.h
  group u_bsp
    u_bsp/: locking.c locking.h mcu_info.h mcu_locks.c mcu_locks.h platform.h r_bsp_config.h r_typedefs.h readme.txt
  group u_bsp/doc
    u_bsp/doc/: r01an2915ej0050_rx65n.pdf

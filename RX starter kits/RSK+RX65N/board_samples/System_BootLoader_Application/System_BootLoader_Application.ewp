# IAR project System_BootLoader_Application.ewp, settings and files
configuration HardwareDebug (RX, debug)
  General.OGChipSelectMenu: R5F565N9 R5F565N9
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x1000
  General.IStackSize: 0x400
  General.HeapSize: 0x400
  ICCRX.CCDefines: __RX
  ICCRX.CCDiagSuppress: Pa050,Pe009,Pe301
  ICCRX.CCIncludePath2: src; src/cg_src
  ICCRX.IccLang: 0
  OBJCOPY.OOCOutputFile: System_BootLoader_Application.mot
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: linker\lnkr5f565n9_Application.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    src/: cgproject.ipcf
  group doc
    doc/: description.txt RSK_Header.txt
  group Renesas_AP/cg_src
    src/cg_src/: r_cg_cgc.c r_cg_cgc.h r_cg_cgc_user.c r_cg_cmt.c r_cg_cmt.h r_cg_cmt_user.c r_cg_icu.c r_cg_icu.h r_cg_icu_user.c r_cg_intprg.c r_cg_iwdt.c r_cg_iwdt.h r_cg_iwdt_user.c r_cg_macrodriver.h r_cg_main.c r_cg_port.c r_cg_port.h r_cg_port_user.c r_cg_sci.c r_cg_sci.h r_cg_sci_user.c r_cg_systeminit.c r_cg_userdefine.h
  group src
    src/: ascii.c ascii.h r_okaya_lcd.c r_okaya_lcd.h r_rsk_async.c r_rsk_async.h rskrx65ndef.h

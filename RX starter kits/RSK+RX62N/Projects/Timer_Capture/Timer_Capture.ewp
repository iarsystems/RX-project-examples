# IAR project Timer_Capture.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F562N8 R5F562N8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDiagSuppress: Pa082
  ICCRX.CCIncludePath2: ../RPDL; ../USBCommon
  ICCRX.IccLang: 0
  OBJCOPY.OOCOutputFile: proj.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: ../RPDL/rx62n_library.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: hwsetup.c lcd.c main_timer_capture.c switch.c timer_capture.c
  group RPDL
    ../RPDL/: interrupt_adc_10.c interrupt_adc_12.c interrupt_bsc.c interrupt_cmt.c interrupt_dmac.c interrupt_exdmac.c interrupt_iic.c Interrupt_INTC.c interrupt_mtu2.c interrupt_not_rpdl.c interrupt_poe.c Interrupt_RTC.c interrupt_sci.c Interrupt_SPI.c Interrupt_TMR.c interrupt_wdt.c
  group USB Common
    ../USBCommon/: usb_hal.c

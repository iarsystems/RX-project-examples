# IAR project System_BootLoader.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F572TK R5F572TK
  General.GenCodeModel: 0
  General.GenDataModel: 2
  General.StackSize: 0x400
  General.IStackSize: 0x1000
  General.HeapSize: 0x400
  ICCRX.CCIncludePath2: src/smc_gen; src/smc_gen/Config_CRC; src/smc_gen/Config_ICU; src/smc_gen/Config_IWDT; src/smc_gen/Config_PORT; src/smc_gen/Config_SCI11; src/smc_gen/Config_TMR0_TMR1; src/smc_gen/general; src/smc_gen/r_bsp; src/smc_gen/r_config; src/smc_gen/r_flash_rx; src/smc_gen/r_flash_rx/src; src/smc_gen/r_flash_rx/src/flash_type_1; src/smc_gen/r_flash_rx/src/flash_type_2; src/smc_gen/r_flash_rx/src/flash_type_3; src/smc_gen/r_flash_rx/src/flash_type_4; src/smc_gen/r_flash_rx/src/targets; src/smc_gen/r_pincfg
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: System_BootLoader.out
  ILINK.IlinkIcfFile: lnkr5f572tk_flash.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: lnkr5f572tk_flash.icf System_BootLoader.ipcf
  group doc
    doc/: description.txt RSK_Header.txt
  group Renesas_AP/smc_gen/Config_CRC
    src/smc_gen/Config_CRC/: Config_CRC.c Config_CRC.h
  group Renesas_AP/smc_gen/Config_ICU
    src/smc_gen/Config_ICU/: Config_ICU.c Config_ICU.h Config_ICU_user.c
  group Renesas_AP/smc_gen/Config_IWDT
    src/smc_gen/Config_IWDT/: Config_IWDT.c Config_IWDT.h Config_IWDT_user.c
  group Renesas_AP/smc_gen/Config_PORT
    src/smc_gen/Config_PORT/: Config_PORT.c Config_PORT.h Config_PORT_user.c
  group Renesas_AP/smc_gen/Config_SCI11
    src/smc_gen/Config_SCI11/: Config_SCI11.c Config_SCI11.h Config_SCI11_user.c
  group Renesas_AP/smc_gen/Config_TMR0_TMR1
    src/smc_gen/Config_TMR0_TMR1/: Config_TMR0_TMR1.c Config_TMR0_TMR1.h Config_TMR0_TMR1_user.c
  group Renesas_AP/smc_gen/general
    src/smc_gen/general/: r_cg_crc.h r_cg_hardware_setup.c r_cg_icu.h r_cg_iwdt.h r_cg_macrodriver.h r_cg_port.h r_cg_sci.h r_cg_tmr.h r_cg_userdefine.h r_cg_wdt.h r_smc_cgc.c r_smc_cgc.h r_smc_cgc_user.c r_smc_entry.h r_smc_interrupt.c r_smc_interrupt.h
  group Renesas_AP/smc_gen/r_bsp
    src/smc_gen/r_bsp/: platform.h readme.txt
  group Renesas_AP/smc_gen/r_bsp/board/generic_rx72t
    src/smc_gen/r_bsp/board/generic_rx72t/: hwsetup.c hwsetup.h r_bsp.h r_bsp_config_reference.h r_bsp_interrupt_config_reference.h resetprg.c vecttbl.c vecttbl.h vollevel.asm
  group Renesas_AP/smc_gen/r_bsp/doc/en
    src/smc_gen/r_bsp/doc/en/: r20an0504es0102-smartconfigurator.pdf
  group Renesas_AP/smc_gen/r_bsp/doc/ja
    src/smc_gen/r_bsp/doc/ja/: r20an0504js0102-smartconfigurator.pdf
  group Renesas_AP/smc_gen/r_bsp/mcu/all
    src/smc_gen/r_bsp/mcu/all/: r_bsp_common.c r_bsp_common.h r_typedefs.h
  group Renesas_AP/smc_gen/r_bsp/mcu/rx72t
    src/smc_gen/r_bsp/mcu/rx72t/: cpu.c cpu.h locking.c locking.h mcu_clocks.c mcu_info.h mcu_init.c mcu_init.h mcu_interrupts.c mcu_interrupts.h mcu_locks.c mcu_locks.h mcu_mapped_interrupts.c mcu_mapped_interrupts.h mcu_mapped_interrupts_private.h
  group Renesas_AP/smc_gen/r_bsp/mcu/rx72t/register_access
    src/smc_gen/r_bsp/mcu/rx72t/register_access/: iodefine.h
  group Renesas_AP/smc_gen/r_config
    src/smc_gen/r_config/: r_bsp_config.h r_bsp_config_readme.txt r_bsp_interrupt_config.h r_flash_rx_config.h
  group Renesas_AP/smc_gen/r_flash_rx
    src/smc_gen/r_flash_rx/: r_flash_rx_if.h readme.txt
  group Renesas_AP/smc_gen/r_flash_rx/doc/en
    src/smc_gen/r_flash_rx/doc/en/: r01an2184eu0350-rx-flash.pdf
  group Renesas_AP/smc_gen/r_flash_rx/doc/ja
    src/smc_gen/r_flash_rx/doc/ja/: r01an2184ju0350-rx-flash.pdf
  group Renesas_AP/smc_gen/r_flash_rx/ref
    src/smc_gen/r_flash_rx/ref/: r_flash_rx_config_reference.h
  group Renesas_AP/smc_gen/r_flash_rx/src
    src/smc_gen/r_flash_rx/src/: r_flash_fcu.c r_flash_fcu.h r_flash_group.c r_flash_group.h r_flash_rx.c r_flash_rx.h r_flash_targets.h
  group Renesas_AP/smc_gen/r_flash_rx/src/flash_type_1
    src/smc_gen/r_flash_rx/src/flash_type_1/: r_codeflash.c r_codeflash.h r_codeflash_extra.c r_codeflash_extra.h r_dataflash.c r_dataflash.h r_flash_common.h r_flash_type1.c r_flash_type1_if.h r_flash_utils.c
  group Renesas_AP/smc_gen/r_flash_rx/src/flash_type_2
    src/smc_gen/r_flash_rx/src/flash_type_2/: r_flash_type2.c r_flash_type2_if.h
  group Renesas_AP/smc_gen/r_flash_rx/src/flash_type_3
    src/smc_gen/r_flash_rx/src/flash_type_3/: r_flash_type3.c r_flash_type3_if.h
  group Renesas_AP/smc_gen/r_flash_rx/src/flash_type_4
    src/smc_gen/r_flash_rx/src/flash_type_4/: r_flash_type4.c r_flash_type4_if.h
  group Renesas_AP/smc_gen/r_flash_rx/src/targets/rx72t
    src/smc_gen/r_flash_rx/src/targets/rx72t/: r_flash_rx72t.h r_mcu_config_reference.h
  group Renesas_AP/smc_gen/r_pincfg
    src/smc_gen/r_pincfg/: Pin.c Pin.h
  group src
    src/: buffer.c buffer.h code_flash.c code_flash.h crc.c crc.h hex.c hex.h main.c r_rsk_utility.c r_rsk_utility.h rskrx72tdef.h srec.c srec.h xmodem.c xmodem.h

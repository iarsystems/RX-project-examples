# IAR project RSKRX111 CoreMark.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F51115 R5F51115
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.StackSize: 0x0
  General.IStackSize: 0x1024
  General.HeapSize: 0x400
  ICCRX.CCDefines: USE_LCD
  ICCRX.CCDiagSuppress: Pa050,Pa082,Pa118,Pe186,Pe191
  ICCRX.CCIncludePath2: r_byteq/; r_byteq/src/; r_config/; r_bsp/; r_sci_async_rx/; r_sci_async_rx/src/; r_cgc_rx/; r_cgc_rx/src/; r_lpc_rx/; r_lpc_rx/src/; r_irq_rx/; r_irq_rx/src/targets/rx111/; src/; src/coremark/
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group r_bsp/board/rskrx111
    r_bsp/board/rskrx111/: getchar.c hwsetup.c hwsetup.h low_level_init.c operating_frequency_set.c putchar.c r_bsp.h r_bsp_config_reference.h rskrx111.h
  group r_bsp/board/user
    r_bsp/board/user/: r_bsp.h
  group r_bsp/mcu/all
    r_bsp/mcu/all/: r_typedefs.h
  group r_bsp/mcu/rx111
    r_bsp/mcu/rx111/: cpu.c cpu.h locking.c locking.h mcu_info.h mcu_locks.c mcu_locks.h
  group r_bsp/mcu/rx111/register_access
    r_bsp/mcu/rx111/register_access/: iodefine.h
  group r_byteq
    r_byteq/: r_byteq_if.h
  group r_byteq/ref
    r_byteq/ref/: r_byteq_config_reference.h
  group r_byteq/src
    r_byteq/src/: r_byteq.c r_byteq_private.h
  group r_cgc_rx/ref
    r_cgc_rx/ref/: r_cgc_config_reference.h
  group r_cgc_rx/src
    r_cgc_rx/src/: r_cgc.c r_cgc.h
  group r_cgc_rx/src/targets/rx62x
    r_cgc_rx/src/targets/rx62x/: r_example_rx62x.c r_example_rx62x.h
  group r_cgc_rx/src/targets/rx63x
    r_cgc_rx/src/targets/rx63x/: r_example_rx63x.c r_example_rx63x.h
  group r_config
    r_config/: r_bsp_config.h r_byteq_config.h r_cgc_config.h r_irq_rx_config.h r_lpc_config.h r_sci_async_rx_config.h r_switches_config.h
  group r_irq_rx
    r_irq_rx/: r_irq_rx_if.h
  group r_irq_rx/ref
    r_irq_rx/ref/: r_irq_rx_config.h
  group r_irq_rx/src/targets/rx111
    r_irq_rx/src/targets/rx111/: r_irq_private.h r_irq_rx.c
  group r_lpc_rx
    r_lpc_rx/: r_lpc_rx_if.h
  group r_lpc_rx/ref
    r_lpc_rx/ref/: r_lpc_config_reference.h
  group r_lpc_rx/src
    r_lpc_rx/src/: r_lpc_rx.c r_lpc_rx.h
  group r_lpc_rx/src/targets/rx62x
    r_lpc_rx/src/targets/rx62x/: r_example_rx62x.c r_example_rx62x.h
  group r_lpc_rx/src/targets/rx63x
    r_lpc_rx/src/targets/rx63x/: r_example_rx63x.c r_example_rx63x.h
  group r_sci_async_rx
    r_sci_async_rx/: r_sci_async_rx_if.h
  group r_sci_async_rx/ref
    r_sci_async_rx/ref/: r_sci_async_rx_config_reference.h
  group r_sci_async_rx/src
    r_sci_async_rx/src/: r_sci_async_rx.c r_sci_async_rx_private.h
  group src
    src/: cmd_parser.c cmd_parser.h lcd.c lcd.h main.c
  group src/coremark
    src/coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_portme.h core_state.c core_util.c coremark.h

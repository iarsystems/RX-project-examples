# IAR project DTC.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F51115 R5F51115
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RX)
  as the first configuration, except:
  ICCRX.CCDefines: NDEBUG
  group (top)
    ./: Description.txt
  group cg_src
    cg_src/: r_cg_cgc.c r_cg_cgc.h r_cg_cgc_user.c r_cg_cmt.c r_cg_cmt.h r_cg_cmt_user.c r_cg_dtc.c r_cg_dtc.h r_cg_dtc_user.c r_cg_icu.c r_cg_icu.h r_cg_icu_user.c r_cg_intprg.c r_cg_macrodriver.h r_cg_main.c r_cg_port.c r_cg_port.h r_cg_port_user.c r_cg_s12adb.c r_cg_s12adb.h r_cg_s12adb_user.c r_cg_sci.c r_cg_sci.h r_cg_sci_user.c r_cg_systeminit.c r_cg_userdefine.h
  group user_src
    cg_src/: ascii.c lcd.c

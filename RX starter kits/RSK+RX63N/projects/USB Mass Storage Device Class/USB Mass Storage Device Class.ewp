# IAR project USB Mass Storage Device Class.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F563NB R5F563NB
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x100
  General.IStackSize: 0x300
  General.HeapSize: 0x400
  ICCRX.CCDiagSuppress: Pa082
  ICCRX.CCIncludePath2: ; USBStack; USBStack\MSC
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: adc.c async.c FAT_0000_200.c FAT_0C00_005.c FAT_0E00_005.c FAT_1000_100.c FAT_5000_041.c hwsetup.c lcd.c main_usb_msc.c switch.c
  group USBStack
    USBStack/: usb_core.c usb_hal.c
  group USBStack/MSC
    USBStack/MSC/: ram_disk.c usb_msc.c usb_msc_scsi.c usbdescriptors.c

# IAR project USB Communication Device Class.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F563NB R5F563NB
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x100
  General.IStackSize: 0x300
  General.HeapSize: 0x400
  ICCRX.CCDiagSuppress: Pa082
  ICCRX.CCIncludePath2: ; USBStack; USBStack\CDC
  ICCRX.IccLang: 0
  OBJCOPY.OOCOutputFile: CDC.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: adc.c async.c hwsetup.c lcd.c main.c switch.c usb_cdc_app.c
  group USBStack
    USBStack/: usb_core.c usb_hal.c
  group USBStack/CDC
    USBStack/CDC/: usb_cdc.c usbdescriptors.c

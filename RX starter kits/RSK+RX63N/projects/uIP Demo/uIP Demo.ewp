# IAR project uIP Demo.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F563NB R5F563NB
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x1000
  General.IStackSize: 0x1000
  General.HeapSize: 0x400
  ICCRX.CCDefines: __LIT
  ICCRX.CCDiagSuppress: Pe111
  ICCRX.CCIncludePath2: ; Ether; uip/uip; uip/unix; uip/apps/dhcpc; uip/apps/webserver
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: hwsetup.c lcd.c led.c low_level_init.c switches.c user-app.c
  group Ether
    Ether/: phy.c r_ether.c
  group uip/apps/dhcpc
    uip/apps/dhcpc/: dhcpc.c
  group uip/apps/webserver
    uip/apps/webserver/: http-strings.c httpd-cgi.c httpd-fs.c httpd.c
  group uip/uip
    uip/uip/: main.c psock.c timer.c uip.c uip_arp.c
  group uip/unix
    uip/unix/: clock-arch.c

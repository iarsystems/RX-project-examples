# IAR project Power_debugging_demo.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F56108 R5F56108
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x300
  General.IStackSize: 0x300
  General.HeapSize: 0x400
  ICCRX.CCIncludePath2: $PROJ_DIR$
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\
  OBJCOPY.OOCOutputFile: Power_debugging_demo_Per.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: lcd.c lcd.h main.c

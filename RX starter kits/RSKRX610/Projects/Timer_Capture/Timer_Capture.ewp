# IAR project Timer_Capture.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F56107 R5F56107
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x300
  General.IStackSize: 0x300
  General.HeapSize: 0x400
  ICCRX.CCDiagSuppress: Pa082
  ICCRX.CCIncludePath2: ../RPDL/; $PROJ_DIR$
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: ../RPDL/RX610_library.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: hwsetup.c lcd.c main_timer_capture.c switch.c timer_capture.c
  group RPDL
    ../RPDL/: Interrupt_ADC_10.c Interrupt_BSC.c Interrupt_CMT.c Interrupt_DMAC.c Interrupt_INTC.c Interrupt_SCI.c Interrupt_TMR.c Interrupt_TPU.c Interrupt_WDT.c

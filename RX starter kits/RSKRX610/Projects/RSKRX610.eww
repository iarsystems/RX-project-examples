<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ADC_OneShot\ADC_OneShot.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ADC_Repeat\ADC_Repeat.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Async_Serial\Async_Serial.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\CRC\CRC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\DMAC\DMAC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\DTC\DTC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Power_Down\Power_Down.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\PWM\PWM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Sync_Serial\Sync_Serial.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Timer_Capture\Timer_Capture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Timer_Compare\Timer_Compare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Timer_Event\Timer_Event.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Timer_Timer\Timer_Timer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Tutorial\Tutorial.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Watchdog\Watchdog.ewp</path>
  </project>
  <batchBuild/>
</workspace>



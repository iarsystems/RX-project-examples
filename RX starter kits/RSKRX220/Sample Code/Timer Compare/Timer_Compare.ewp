# IAR project Timer_Compare.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F52206B R5F52206B
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  group C source file
    ./: excep_BRK.c hwsetup.c lcd.c low_level_init.c main_timer_output.c switch.c timer_output.c
  group Text Files
    ./: Description.txt RSK_Header.txt

# IAR project ADC12_Oneshot.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F52206B R5F52206B
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x200
  General.HeapSize: 0x400
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group C source file
    ./: adc12oneshot.c excep_BRK.c hwsetup.c lcd.c low_level_init.c main_adc12_oneshot.c switch.c
  group Text Files
    ./: Description.txt RSK_Header.txt

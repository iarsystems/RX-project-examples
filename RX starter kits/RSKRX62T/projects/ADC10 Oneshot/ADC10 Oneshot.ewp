# IAR project ADC10 Oneshot.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F562TA R5F562TA
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDiagSuppress: Pa082
  ICCRX.CCIncludePath2: ../RPDL/
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: ADC10one.c hwsetup.c lcd.c main_adc10_oneshot.c switch.c
    ../RPDL/: RX62T_library.a
  group RPDL
    ../RPDL/: Interrupt_ADC_10.c Interrupt_ADC_12.c Interrupt_BSC.c Interrupt_CMT.c Interrupt_GPT.c Interrupt_IIC.c Interrupt_INTC.c Interrupt_LIN.c Interrupt_MTU3.c Interrupt_not_RPDL.c Interrupt_POE.c Interrupt_SCI.c Interrupt_SPI.c Interrupt_WDT.c
  group Text Files
    ./: description.txt RSK_Header.txt

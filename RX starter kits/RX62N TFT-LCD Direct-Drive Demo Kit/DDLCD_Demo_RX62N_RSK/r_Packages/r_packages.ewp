# IAR project r_packages.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F562N8 R5F562N8
  General.GenCodeModel: 0
  General.GenDataModel: 2
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDiagSuppress: Pa082
  ICCRX.CCIncludePath2: r_ddlcd/src/; config/; include/; r_freertos/source/include/; r_freertos/source/portable/IAR/RX600/
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  group Config
    config/: config_r_ddlcd.h config_r_ddlcd_panel.h config_r_ddlcd_platform.h config_r_freertos.h config_r_gapi.h config_r_Packages.h freertosconfig.h
  group r_ddlcd/API
    r_ddlcd/src/: r_ddlcd_exmemory.h r_ddlcd_public.h
  group r_ddlcd/Source
    targetmcu/rx62n/: r_ddlcd.c
    r_ddlcd/src/: r_ddlcd_exmemory.c r_ddlcd_frames.c
  group r_freertos/API
    r_freertos/source/include/: croutine.h FreeRTOS.h queue.h semphr.h task.h
  group r_freertos/Source
    r_freertos/source/: croutine.c list.c queue.c tasks.c
    r_freertos/source/portable/MemMang/: heap_3.c
    r_freertos/source/portable/IAR/RX600/: port.c port_asm.s
  group r_gapi/API
    r_gapi/src/: r_gapic_core.h r_gapiu_utility.h r_gapiw_wrapper.h
  group r_gapi/Source
    r_gapi/src/: r_gapic_copy.c r_gapic_font.c r_gapic_gradient.c r_gapic_xlate.c r_gapiu_bmp.c r_gapiu_memory.c r_gapiw_button.c r_gapiw_scroll.c

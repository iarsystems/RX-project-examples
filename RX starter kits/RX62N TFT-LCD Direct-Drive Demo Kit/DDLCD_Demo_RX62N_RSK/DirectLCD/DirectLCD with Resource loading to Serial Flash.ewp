# IAR project DirectLCD with Resource loading to Serial Flash.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F562N8 R5F562N8
  General.GenCodeModel: 0
  General.GenDataModel: 2
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x3c00
  ICCRX.CCDefines: LOAD_RESOURCES_TO_SERIAL_FLASH=1
  ICCRX.CCDiagSuppress: Pa082, Pe177
  ICCRX.CCIncludePath2: ; ../CommonSource/; ../r_Packages/include/; ../r_Packages/config/; ../r_Packages/r_freertos/source/include/; ../r_Packages/r_gapi/src/; ../r_Packages/r_ddlcd/src/
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkKeepSymbols: Resources
  ILINK.IlinkIcfFile: lnkr5f562n8_DirectLCD.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group C source file
    ../CommonSource/: main.c
  group C source file/Framegroup
    ../CommonSource/: EventMgr.c Frames.c ScreenMgr.c ScreenObjs.c touchscreen.c
  group C source file/Screens
    ../CommonSource/: ScreenHome.c
  group C source file/Screens/Home
    ../CommonSource/: ScreenHomeClassic.c ScreenMed.c ScreenRefrig.c ScreenThermo.c
  group C source file/Screens/Home/Classic
    ../CommonSource/: ScreenAnimate.c ScreenCalibrate.c ScreenCountdown.c ScreenIO.c ScreenSlider.c ScreenWrites.c
  group C source file/System
    ./: hwsetup_platform.c low_level_init.c
  group C source file/Utilities
    ../CommonSource/: simple_printf.c timer_rtc.c
  group C source file/Utilities/Serial Flash
    ../CommonSource/: crc.c FindFile.c Resources.c
    ../CommonSource/SerialFlash/: FlashSerialSST.c SPI_viaRSPI.c
  group Library file
    ../r_Packages/Debug/Exe/: r_packages.a r_packages_prebuilt.a

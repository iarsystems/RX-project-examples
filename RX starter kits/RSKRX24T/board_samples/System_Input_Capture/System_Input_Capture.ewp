# IAR project System_Input_Capture.ewp, settings and files
configuration HardwareDebug (RX, debug)
  General.OGChipSelectMenu: R5F524TA R5F524TA
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x100
  General.IStackSize: 0x300
  General.HeapSize: 0x400
  ICCRX.CCDefines: __RX
  ICCRX.CCDiagSuppress: Pa050,Pe009,Pe301
  ICCRX.CCIncludePath2: src; src/cg_src
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    src/: cgproject.ipcf
  group doc
    doc/: description.txt RSK_Header.txt
  group Renesas_AP/cg_src
    src/cg_src/: r_cg_cgc.c r_cg_cgc.h r_cg_cgc_user.c r_cg_cmt.c r_cg_cmt.h r_cg_cmt_user.c r_cg_icu.c r_cg_icu.h r_cg_icu_user.c r_cg_intprg.c r_cg_lpc.c r_cg_lpc.h r_cg_lpc_user.c r_cg_macrodriver.h r_cg_main.c r_cg_port.c r_cg_port.h r_cg_port_user.c r_cg_riic.c r_cg_riic.h r_cg_riic_user.c r_cg_s12ad.c r_cg_s12ad.h r_cg_s12ad_user.c r_cg_sci.c r_cg_sci.h r_cg_sci_user.c r_cg_systeminit.c r_cg_tmr.c r_cg_tmr.h r_cg_tmr_user.c r_cg_userdefine.h
  group src
    src/: ascii.c ascii.h iodefine.h r_okaya_lcd.c r_okaya_lcd.h r_rsk_iic_eeprom.c r_rsk_iic_eeprom.h r_rsk_nvm.c r_rsk_nvm.h r_rsk_switch.c r_rsk_switch.h rskrx24tdef.h

# IAR project FPU Bouncing Ball.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F562N8 R5F562N8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDiagSuppress: Pa082
  ICCRX.CCIncludePath2: ..\..\RPDL\
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: ..\..\RPDL\RX62N_library_LQFP_100.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Ball.c ball_fpu.c hwsetup.c lcd_graphics.c main.c sprite_images.c switch.c YRDKRX62N_RSPI_API.c
  group RPDL
    ../../RPDL/: Interrupt_ADC_10.c Interrupt_ADC_12.c Interrupt_BSC.c Interrupt_CMT.c Interrupt_DMAC.c Interrupt_EXDMAC.c Interrupt_IIC.c Interrupt_INTC.c Interrupt_MTU2.c Interrupt_not_RPDL.c Interrupt_POE.c Interrupt_RTC.c Interrupt_SCI.c Interrupt_SPI.c Interrupt_TMR.c Interrupt_WDT.c

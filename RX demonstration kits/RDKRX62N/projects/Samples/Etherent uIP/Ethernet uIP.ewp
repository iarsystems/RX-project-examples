# IAR project Ethernet uIP.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F562N8 R5F562N8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x100
  General.IStackSize: 0x200
  General.HeapSize: 0x400
  ICCRX.CCDiagSuppress: Pa082,Pe550
  ICCRX.CCIncludePath2: ../../RPDL/; src/bsp; src/driver; src/user-app; src/uip/uip; src/uip/unix; src/uip/apps/dhcpc; src/uip/apps/webserver
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$/inc/
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: ../../RPDL/RX62N_library_LQFP_100.a; ../../LCD/glyphlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    src/bsp/: hwsetup.c lcd.c switch.c YRDKRX62N_RSPI_API.c
  group driver
    src/driver/: phy.c r_ether.c
  group RPDL
    ../../RPDL/: Interrupt_ADC_10.c Interrupt_ADC_12.c Interrupt_BSC.c Interrupt_CMT.c Interrupt_DMAC.c Interrupt_IIC.c Interrupt_INTC.c Interrupt_MTU2.c Interrupt_not_RPDL.c Interrupt_POE.c Interrupt_SCI.c Interrupt_SPI.c Interrupt_TMR.c Interrupt_WDT.c
  group uip/apps/dhcpc
    src/uip/apps/dhcpc/: dhcpc.c
  group uip/apps/webserver
    src/uip/apps/webserver/: http-strings.c httpd-cgi.c httpd-fs.c httpd.c
  group uip/uip
    src/uip/uip/: main.c psock.c timer.c uip-fw.c uip-neighbor.c uip-split.c uip.c uip_arp.c uiplib.c
  group uip/unix
    src/uip/unix/: clock-arch.c
  group user-app
    src/user-app/: user-app.c

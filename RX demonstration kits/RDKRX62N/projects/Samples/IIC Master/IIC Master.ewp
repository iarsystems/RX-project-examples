# IAR project IIC Master.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F562N8 R5F562N8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x100
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: RX62N=1
  ICCRX.CCDiagSuppress: Pa082
  ICCRX.CCIncludePath2: ../../RPDL/; 
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$/inc/
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: ../../RPDL/RX62N_library_LQFP_100.a; ../../LCD/GlyphLib_v2.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: accelerometer.c hwsetup.c lcd.c main_iic_master.c switch.c thermal_sensor.c YRDKRX62N_RSPI_API.c
  group RPDL
    ../../RPDL/: Interrupt_ADC_10.c Interrupt_CMT.c Interrupt_DMAC.c Interrupt_IIC.c Interrupt_INTC.c Interrupt_not_RPDL.c Interrupt_SCI.c Interrupt_TMR.c Interrupt_WDT.c

# IAR project USB Human Interface Device Class.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F562N8 R5F562N8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x100
  General.IStackSize: 0x250
  General.HeapSize: 0x400
  ICCRX.CCDiagSuppress: Pa082
  ICCRX.CCIncludePath2: ..\..\RPDL\; target\app\; target\sample\; target\usbstack\; target\usbstack\hid\
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: ..\..\RPDL\RX62N_library_LQFP_100.a; ..\..\LCD\glyphlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    target/sample/: async.c hwsetup.c lcd.c main.c switch.c
  group RPDL
    ../../RPDL/: Interrupt_ADC_10.c Interrupt_BSC.c Interrupt_CMT.c Interrupt_DMAC.c Interrupt_IIC.c Interrupt_INTC.c Interrupt_SCI.c Interrupt_TMR.c Interrupt_WDT.c
    target/RPDL/: Interrupt_not_RPDL.c
  group USB
    target/usbstack/: usb_core.c usb_hal.c
    target/usbstack/hid/: usb_hid.c usbdescriptors.c
    target/app/: usb_hid_app.c

# IAR project Flash Data.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F562N8 R5F562N8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x200
  General.HeapSize: 0x400
  ICCRX.CCDefines: RX62N=1
  ICCRX.CCDiagSuppress: Pa082
  ICCRX.CCIncludePath2: ..\..\RPDL\; R_FlashAPI\
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: ..\..\RPDL\RX62N_library_LQFP_100.a; ..\..\LCD\GlyphLib_v2.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: flash_data.c hwsetup.c lcd.c main_fla_data.c switch.c YRDKRX62N_RSPI_API.c
  group Flash API
    R_FlashAPI/: r_Flash_API_RX600.c
  group RPDL
    ../../RPDL/: Interrupt_ADC_12.c Interrupt_BSC.c Interrupt_CMT.c Interrupt_DMAC.c Interrupt_IIC.c Interrupt_INTC.c Interrupt_MTU2.c Interrupt_not_RPDL.c Interrupt_SCI.c Interrupt_SPI.c Interrupt_TMR.c Interrupt_WDT.c

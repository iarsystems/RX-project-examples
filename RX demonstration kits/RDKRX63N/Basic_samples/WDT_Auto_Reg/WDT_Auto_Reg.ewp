# IAR project WDT_Auto_Reg.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F563NB R5F563NB
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: PLATFORM_RDK63N
  ICCRX.IccLang: 0
  OBJCOPY.OOCOutputFile: templateproject.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: lnk_no_ofs0_r5f563nb.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: ..\LCDLib\glyphlib_v2.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: cgc.c hwsetup.c lcd.c low_level_init.c main.c wdt.c yrdkrx62n_rspi_api.c

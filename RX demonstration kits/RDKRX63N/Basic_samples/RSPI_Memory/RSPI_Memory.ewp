# IAR project RSPI_Memory.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F563NB R5F563NB
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCIncludePath2: ../Common
  ICCRX.IccLang: 0
  OBJCOPY.OOCOutputFile: proj.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: ../LCDLib/glyphlib_v2.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: flash_demo_functions.c lcd.c P5Q.c rspi_PCMflash_main.c yrdkrx62n_rspi_api.c
  group Common
    ../Common/: hwsetup.c low_level_init.c

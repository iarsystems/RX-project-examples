# IAR project Power_Modes.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F563NB R5F563NB
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCIncludePath2: ../Common; ../r_glyph/glyph; ../r_glyph/glyph/fonts; ../r_glyph/glyph/st7579; ../r_rspi_rx600; ../r_switches
  ICCRX.IccLang: 0
  OBJCOPY.OOCOutputFile: proj.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: pmdemo_switches.c power_modes_demo.c power_modes_main.c
  group Common
    ../Common/: hwsetup.c lcd.c low_level_init.c
  group LCD
    ../r_glyph/glyph/fonts/: font_8x8.c
    ../r_glyph/glyph/: glyph.c
    ../r_glyph/: r_glyph.c r_glyph_register.c
    ../r_glyph/glyph/st7579/: st7579_lcd.c
  group RSPI
    ../r_rspi_rx600/: r_rspi_rx600.c
  group Switch
    ../r_switches/: r_switches.c

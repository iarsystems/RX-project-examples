# IAR project PspSimplePort.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F56108 R5F56108
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x100
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  group (top)
    ./: PspSimplePort.c

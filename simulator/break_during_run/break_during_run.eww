<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\break_during_run.ewp</path>
  </project>
  <batchBuild/>
</workspace>



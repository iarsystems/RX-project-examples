# IAR project static_part.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F56104 R5F56104
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x100
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\
  ILINK.IlinkOutputFile: static_part.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: extra_image.tab
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: static_main.c

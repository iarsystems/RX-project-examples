<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\static_part.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\extra_image.ewp</path>
  </project>
  <batchBuild/>
</workspace>


